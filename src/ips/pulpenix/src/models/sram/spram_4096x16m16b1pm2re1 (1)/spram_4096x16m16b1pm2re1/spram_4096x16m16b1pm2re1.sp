* Spice generated by MemoryCanvas
* Version: SDT_MC_15.00.02
* Fri Jun 14 12:11:55 EDT 2019

*.GLOBAL bulk!
*.GLOBAL bulk!

.SUBCKT sxmodel a b
.ENDS

.SUBCKT d_avtnfet_bc d g s x b
.ENDS

.SUBCKT d_avtanfet_bc d g s x b
.ENDS

.SUBCKT d_avtmnfet_bc d g s x b
.ENDS

.SUBCKT d_tonfet_bc d g s x b
.ENDS

.SUBCKT d_tohvdnfet_bc d g s x b
.ENDS

.SUBCKT d_tomnfet_bc d g s x b
.ENDS

.SUBCKT d_tolnfet_bc d g s x b
.ENDS

.SUBCKT d_toxlnfet_bc d g s x b
.ENDS

.SUBCKT d_avtpfet_bc d g s x b
.ENDS

.SUBCKT d_avtapfet_bc d g s x b
.ENDS

.SUBCKT d_avtmpfet_bc d g s x b
.ENDS

.SUBCKT d_topfet_bc d g s x b
.ENDS

.SUBCKT d_tohvdpfet_bc d g s x b
.ENDS

.SUBCKT d_tompfet_bc d g s x b
.ENDS

.SUBCKT d_tolpfet_bc d g s x b
.ENDS

.SUBCKT d_toxlpfet_bc d g s x b
.ENDS

.SUBCKT d_nfett d g s x t
.ENDS

.SUBCKT d_hvtnfett d g s x t
.ENDS

.SUBCKT d_svtnfett d g s x t
.ENDS

.SUBCKT d_uvtnfett d g s x t
.ENDS

.SUBCKT d_avtnfett d g s x t
.ENDS

.SUBCKT d_tonfett d g s x t
.ENDS

.SUBCKT d_pfett d g s x t
.ENDS

.SUBCKT d_hvtpfett d g s x t
.ENDS

.SUBCKT d_svtpfett d g s x t
.ENDS

.SUBCKT d_uvtpfett d g s x t
.ENDS

.SUBCKT d_avtpfett d g s x t
.ENDS

.SUBCKT d_topfett d g s x t
.ENDS

.SUBCKT d_todiode_soi a c g x
.ENDS

.SUBCKT d_todiode_esd pd nd gate sx
.ENDS

.SUBCKT d_sbdiode_esd pd nd sx
.ENDS

.SUBCKT bitieres in x
.ENDS

.SUBCKT fuse in out
.ENDS

.SUBCKT singlecpw va vb vshield
.ENDS

.SUBCKT coupledcpw va1 va2 vb1 vb2 vshield
.ENDS

.SUBCKT singlewire va vb vshield
.ENDS

.SUBCKT coupledwires va1 va2 vb1 vb2 vshield
.ENDS

.SUBCKT symindp outpr outse ct ref
.ENDS

.SUBCKT d_esdscr_sblk pd nb pb nd sx
.ENDS

.SUBCKT d_esdbdscr pd nd sx
.ENDS

.SUBCKT bondpad in gp x
.ENDS

.SUBCKT indr in out ref
.ENDS

.SUBCKT indrp in out ref
.ENDS

.SUBCKT symindr outpr outse ct ref
.ENDS

.SUBCKT symindrp outpr outse ct ref
.ENDS

.SUBCKT rf_avtnfet_bc d g s x b
.ENDS

.SUBCKT rf_tonfet_bc d g s x b
.ENDS

.SUBCKT rf_nfett d g s x t
.ENDS

.SUBCKT rf_tonfett d g s x t
.ENDS

.SUBCKT rf_pfett d g s x t
.ENDS

.SUBCKT rf_topfett d g s x t
.ENDS

.SUBCKT esdnsh_bc_base d g s b
.ENDS

.SUBCKT bendm va vb vshield
.ENDS

.SUBCKT gapm ga gb vshield
.ENDS

.SUBCKT openm vopen vshield
.ENDS

.SUBCKT shortm vshort vshield
.ENDS

.SUBCKT stepm stepa stepb vshield
.ENDS

.SUBCKT teem va vb vc vshield
.ENDS

.SUBCKT taperm ta tb vshield
.ENDS

.SUBCKT radialstubm rsa vshield
.ENDS

.SUBCKT red_gctl BPUI CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] EN
+ ENB GRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RMO[0] RMO[1] RMO[2] RWOUT SPUI T1EN VSB[1] VSB[2] VSB[3]
+ VSB[4] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO GRST:I CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O CSH_YS[2]:O
*.PININFO CSH_YS[3]:O EN:O ENB:O QT[2]:O QT[3]:O QT[4]:O QT[5]:O QT[6]:O
*.PININFO QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O QT[13]:O RMO[0]:O
*.PININFO RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O WMO[2]:O ZRR:O
*.PININFO BPUI:B PWR:B SPUI:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B ag_ctrl:B
.ENDS

.SUBCKT pch_svtx B D G S m=1
*.PININFO B:B D:B G:B S:B
MP1 D G S bulk! d_hvtpfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT nch_svtx B D G S m=1
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_hvtnfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT inv_svtx G Gb IN OUT P Pb
*.PININFO IN:I OUT:O G:B Gb:B P:B Pb:B
XI7 Pb P IN OUT / pch_svtx nf=1 w=p_w m=pm
XI4 Gb OUT IN G / nch_svtx nf=1 w=n_w m=nm
.ENDS

.SUBCKT nch B D G S m=1
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_hvtnfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT pch B D G S m=1
*.PININFO B:B D:B G:B S:B
MP0 D G S bulk! d_hvtpfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT nand2 A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XN0 Gb Y A net10 / nch nf=1 w=n_w m=nm
XN1 Gb net10 B G / nch nf=1 w=n_w m=nm
XP0 Pb P A Y / pch nf=1 w=p_w m=pm
XP1 Pb P B Y / pch nf=1 w=p_w m=pm
.ENDS

.SUBCKT mux21 A0 A1 EN ENB G Gb P Pb Y
*.PININFO A0:I A1:I EN:I ENB:I G:B Gb:B P:B Pb:B Y:B
XI27 net019 net018 G Gb P Pb Y / nand2 pm=1 p_w=360n nm=1 n_w=360n
XI198 A1 EN G Gb P Pb net018 / nand2 pm=1 p_w=240n nm=1 n_w=240n
XI36 A0 ENB G Gb P Pb net019 / nand2 pm=1 p_w=240n nm=1 n_w=240n
.ENDS

.SUBCKT ant_diode D S m=1
*.PININFO D:B S:B
MN0 D S S bulk! d_nfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0 diffL=119.00n
+ diffM=150.0n diffR=119.00n composite=0 local_sigma=0 pu0mult=1e35 pla=0
+ pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1 pre_layout_local=-1 pdevdops=1
+ pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w nrd=7.5e-08/w
.ENDS

.SUBCKT pch_svt B D G S m=1
*.PININFO B:B D:B G:B S:B
MP1 D G S bulk! d_hvtpfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT nch_svt B D G S m=1
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_hvtnfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT tri_svt A EN ENB G Gb P Pb Y
*.PININFO A:I EN:I ENB:I G:B Gb:B P:B Pb:B Y:B
XP0 Pb net13 ENB Y / pch_svt nf=1 w=p_w m=pm
XI12 Pb P A net13 / pch_svt nf=1 w=p_w m=pm
XN0 Gb Y EN net12 / nch_svt nf=1 w=n_w m=nm
XN1 Gb net12 A G / nch_svt nf=1 w=n_w m=nm
.ENDS

.SUBCKT inv_svt G Gb IN OUT P Pb
*.PININFO IN:I OUT:O G:B Gb:B P:B Pb:B
XI10 Pb P IN OUT / pch_svt nf=1 w=p_w m=pm
XI4 Gb OUT IN G / nch_svt nf=1 w=n_w m=nm
.ENDS

.SUBCKT globlat A CB CT PWR QB QT VDDP VSS
*.PININFO A:I CB:I CT:I QB:O QT:O PWR:B VDDP:B VSS:B
XI16 VDDP PWR QT net032 / pch nf=1 w=240n m=1
XI17 VDDP net032 CT z1 / pch nf=1 w=240n m=1
XI21 A CT CB VSS VSS PWR VDDP z1 / tri_svt nm=2 n_w=240n pm=1 p_w=800n
XI14 VSS VSS z1 QT PWR VDDP / inv_svt nm=2 n_w=240n pm=2 p_w=400n
XI15 VSS VSS QT QB PWR VDDP / inv_svt nm=2 n_w=240n pm=1 p_w=800n
XI18 VSS z1 CB net023 / nch nf=1 w=240n m=1
XI19 VSS net023 QT VSS / nch nf=1 w=240n m=1
.ENDS

.SUBCKT pch_lvtx B D G S m=1
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_pfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0 diffL=119.00n
+ diffM=150.0n diffR=119.00n composite=0 local_sigma=0 pu0mult=1e35 pla=0
+ pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1 pre_layout_local=-1 pdevdops=1
+ pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w nrd=7.5e-08/w
.ENDS

.SUBCKT nch_lvtx B D G S m=1
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_nfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0 diffL=119.00n
+ diffM=150.0n diffR=119.00n composite=0 local_sigma=0 pu0mult=1e35 pla=0
+ pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1 pre_layout_local=-1 pdevdops=1
+ pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w nrd=7.5e-08/w
.ENDS

.SUBCKT inv_lvtx G Gb IN OUT P Pb
*.PININFO IN:I OUT:O G:B Gb:B P:B Pb:B
XI7 Pb P IN OUT / pch_lvtx nf=1 w=p_w m=pm
XI4 Gb OUT IN G / nch_lvtx nf=1 w=n_w m=nm
.ENDS

.SUBCKT gio BADIO BWM D LBWM LBWMB LCLKIO LDB LD PREOUTQ PWR Q SWT TBWM TD TE VDDA VNW
+ VSS
*.PININFO BWM:I D:I TBWM:I TD:I Q:O BADIO:B LBWM:B LCLKIO:B LDB:B PREOUTQ:B
*.PININFO PWR:B SWT:B TE:B VDDA:B VNW:B VSS:B
XI194 VSS VSS TE NTE PWR VNW / inv_svtx nm=1 n_w=480n pm=1 p_w=720n
XI215 VSS VSS QB Q PWR VNW / inv_svtx nm=1 n_w=480n pm=1 p_w=800n
XI214 VSS VSS PREOUTQ PRQB PWR VNW / inv_svtx nm=1 n_w=480n pm=1 p_w=720n
XI203 VSS VSS SWT net035 PWR VNW / inv_svtx nm=1 n_w=240n pm=1 p_w=360n
XI188 D TD TE NTE VSS VSS PWR VNW MD / mux21
XI201 LQB LDB SWT net035 VSS VSS PWR VNW QB / mux21
XI196 BWM TBWM TE NTE VSS VSS PWR VNW MBW / mux21
XD1 TD VSS / ant_diode nf=1 w=240nm m=1
XD6 TBWM VSS / ant_diode nf=1 w=240nm m=1
XD5 D VSS / ant_diode nf=1 w=240nm m=1
XD8 BWM VSS / ant_diode nf=1 w=240nm m=1
XD9 BADIO VSS / ant_diode nf=1 w=240nm m=1
XI39 MD CT CB PWR LDB LD VNW VSS / globlat
XI43 MBW CT CB PWR LBWMB LBWM VNW VSS / globlat
XI202 PRQB CT CB PWR net055 LQB VNW VSS / globlat
XI192 VSS VSS CB CT PWR VNW / inv_lvtx nm=1 n_w=480n pm=1 p_w=720n
XI149 VSS VSS LCLKIO CB PWR VNW / inv_lvtx nm=1 n_w=480n pm=1 p_w=720n
.ENDS

.SUBCKT gio2 BADIO BWM D LBWM LBWMB LCLKIO LDB LD PREOUTQ PWR Q SWT TBWM TD TE VDDA VNW
+ VSS
*.PININFO BWM:I D:I TBWM:I TD:I Q:O BADIO:B LBWM:B LCLKIO:B LDB:B PREOUTQ:B
*.PININFO PWR:B SWT:B TE:B VDDA:B VNW:B VSS:B
XXGIO BADIO BWM D LBWM LBWMB LCLKIO LDB LD PREOUTQ PWR Q SWT TBWM TD TE VDDA VNW VSS /
+ gio
.ENDS

.SUBCKT gio_edge LCLKIO PWR SWT TE VDDA VNW VSS
*.PININFO LCLKIO:B PWR:B SWT:B TE:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT nch_lvt B D G S m=1
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_nfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0 diffL=119.00n
+ diffM=150.0n diffR=119.00n composite=0 local_sigma=0 pu0mult=1e35 pla=0
+ pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1 pre_layout_local=-1 pdevdops=1
+ pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w nrd=7.5e-08/w
.ENDS

.SUBCKT pch_lvt B D G S m=1
*.PININFO B:B D:B G:B S:B
MP0 D G S bulk! d_pfet m=1 l=40n w=w nf=nf par=1 gcon=1 optNum=0 diffL=119.00n
+ diffM=150.0n diffR=119.00n composite=0 local_sigma=0 pu0mult=1e35 pla=0
+ pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1 pre_layout_local=-1 pdevdops=1
+ pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w nrd=7.5e-08/w
.ENDS

.SUBCKT txgate_lvtx E EB Gb IN OUT Pb
*.PININFO E:I EB:I Gb:B IN:B OUT:B Pb:B
XN0 Gb IN E OUT / nch_lvt nf=1 w=n_w m=nm
XP0 Pb OUT EB IN / pch_lvt nf=1 w=p_w m=pm
.ENDS

.SUBCKT inv G Gb IN OUT P Pb
*.PININFO IN:I OUT:O G:B Gb:B P:B Pb:B
XN0 Gb OUT IN G / nch nf=1 w=n_w m=nm
XP0 Pb P IN OUT / pch nf=1 w=p_w m=pm
.ENDS

.SUBCKT red_gio BADIO BWBR0 BWBR1 DBR0 DBR1 GBW GD LBWM LDB PREOUT PREOUTQ
+ PREOUTS PWR RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO GBW:O GD:O PREOUTQ:O BADIO:B BWBR0:B BWBR1:B DBR0:B DBR1:B LBWM:B
*.PININFO LDB:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B RPFEED[1]:B RPIN:B
*.PININFO RPOUT:B VDDA:B VNW:B VSS:B
XI166 RED REDB VSS BWBR1 LBWM VNW / txgate_lvtx pm=2 p_w=360n nm=2 n_w=360n
XI159 RED REDB VSS DBR1 LDB VNW / txgate_lvtx pm=2 p_w=360n nm=2 n_w=360n
XI165 REDB RED VSS BWBR0 LBWM VNW / txgate_lvtx pm=2 p_w=360n nm=2 n_w=360n
XI164 REDB RED VSS DBR0 LDB VNW / txgate_lvtx pm=2 p_w=360n nm=2 n_w=360n
XI147 VSS VSS DBR0 GD PWR VNW / inv_lvtx nm=2 n_w=360n pm=2 p_w=540n
XI146 VSS VSS BWBR0 GBW PWR VNW / inv_lvtx nm=2 n_w=360n pm=2 p_w=540n
XI179 VSS VSS REDB RED PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI173 VSS VSS RPOUT REDB PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI167 VSS VSS RPIN net0104 PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI181 VNW PWR BADB DBR0 / pch nf=1 w=240n m=1
XI180 VNW PWR BADB BWBR0 / pch nf=1 w=240n m=1
XI168 net0104 BADB VSS VSS PWR VNW RPOUT / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI160 net0104 BADIO VSS VSS PWR VNW BADB / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI191 PREOUT PREOUTS RED REDB VSS VSS PWR VNW PREOUTQ / mux21
.ENDS

.SUBCKT red_gio4 BADIO BWBR0 BWBR1 DBR0 DBR1 GBW GD LBWM LDB PREOUT PREOUTQ
+ PREOUTS PWR RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO PREOUTQ:O BADIO:B BWBR0:B BWBR1:B DBR0:B DBR1:B GBW:B GD:B LBWM:B
*.PININFO LDB:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B RPFEED[1]:B RPIN:B
*.PININFO RPOUT:B VDDA:B VNW:B VSS:B
Xred BADIO BWBR0 BWBR1 DBR0 DBR1 GBW GD LBWM LDB PREOUT PREOUTQ PREOUTS PWR
+ RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS / red_gio
.ENDS

.SUBCKT nor2 A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XP1 Pb P B net12 / pch nf=1 w=p_w m=pm
XP0 Pb net12 A Y / pch nf=1 w=p_w m=pm
XN0 Gb Y A G / nch nf=1 w=n_w m=nm
XN1 Gb Y B G / nch nf=1 w=n_w m=nm
.ENDS

.SUBCKT gcsmx4 CS[0] CS[1] CS[2] CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] PWR Q0 QB0 QB1 QB2 QB3 VDDA VNW VSS
*.PININFO CS[0]:B CS[1]:B CS[2]:B CS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B
*.PININFO GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B
*.PININFO GRD3[2]:B GRD3[3]:B PWR:B Q0:B QB0:B QB1:B QB2:B QB3:B VDDA:B VNW:B
*.PININFO VSS:B
XI177 QB0 QB1 CS[1] CS[0] VSS VSS PWR VNW net013 / mux21
XI178 QB2 QB3 CS[3] CS[2] VSS VSS PWR VNW net012 / mux21
XI179 net012 net013 VSS VSS PWR VNW Q0 / nor2 nm=1 n_w=400n pm=1 p_w=800n
.ENDS

.SUBCKT gcsmx_edge CS[0] CS[1] CS[2] CS[3] PWR VDDA VNW VSS
*.PININFO CS[0]:B CS[1]:B CS[2]:B CS[3]:B PWR:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT grdmx_edge BS[0] BS[1] BS[2] BS[3] PWR VDDA VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B PWR:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT nored_gio1 BADIO BWBR0 BWBR1 DBR0 DBR1 LBWM LDB PREOUT PREOUTS PWR
+ RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO BADIO:B BWBR0:B BWBR1:B DBR0:B DBR1:B LBWM:B LDB:B PREOUT:B
*.PININFO PREOUTS:B PWR:B QB0:B RPFEED[0]:B RPFEED[1]:B RPIN:B RPOUT:B VDDA:B
*.PININFO VNW:B VSS:B
.ENDS

.SUBCKT inv_lvt G Gb IN OUT P Pb
*.PININFO IN:I OUT:O G:B Gb:B P:B Pb:B
XI4 Gb OUT IN G / nch_lvt nf=1 w=n_w m=nm
XI7 Pb P IN OUT / pch_lvt nf=1 w=p_w m=pm
.ENDS

.SUBCKT gio_rebuf LCLKIO LCLKIOI PWR SWT SWTI TE TEI VDDA VNW VSS
*.PININFO LCLKIO:B LCLKIOI:B PWR:B SWT:B SWTI:B TE:B TEI:B VDDA:B VNW:B VSS:B
XI20 VSS VSS TEI net032 PWR VNW / inv_lvt pm=1 p_w=480n nm=1 n_w=240n
XI19 VSS VSS net032 TE PWR VNW / inv_lvt pm=2 p_w=960n nm=2 n_w=480n
XI11 VSS VSS net033 LCLKIO PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI25 VSS VSS net035 SWT PWR VNW / inv_lvt pm=2 p_w=960n nm=2 n_w=480n
XI26 VSS VSS SWTI net035 PWR VNW / inv_lvt pm=1 p_w=480n nm=1 n_w=240n
XI12 VSS VSS LCLKIOI net033 PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
.ENDS

.SUBCKT nored_gio2 BADIO BWBR0 BWBR1 DBR0 DBR1 LBWM LDB PREOUT PREOUTQ PREOUTS
+ PWR RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO BADIO:B BWBR0:B BWBR1:B DBR0:B DBR1:B LBWM:B LDB:B PREOUT:B
*.PININFO PREOUTQ:B PREOUTS:B PWR:B RPFEED[0]:B RPFEED[1]:B RPIN:B RPOUT:B
*.PININFO VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT nored_gio_rebuf BWBR0 BWBR1 DBR0 DBR1 PREOUT PREOUTS PWR RPFEED[0]
+ RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO BWBR0:B BWBR1:B DBR0:B DBR1:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B
*.PININFO RPFEED[1]:B RPIN:B RPOUT:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT nored_gio4 BADIO BWBR0 BWBR1 DBR0 DBR1 LBWM LDB PREOUT PREOUTQ PREOUTS
+ PWR RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO BADIO:B BWBR0:B BWBR1:B DBR0:B DBR1:B LBWM:B LDB:B PREOUT:B
*.PININFO PREOUTQ:B PREOUTS:B PWR:B RPFEED[0]:B RPFEED[1]:B RPIN:B RPOUT:B
*.PININFO VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT red_gio_edge BWBR0 BWBR1 DBR0 DBR1 PREOUT PREOUTS PWR RPFEED[0]
+ RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO BWBR0:B BWBR1:B DBR0:B DBR1:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B
*.PININFO RPFEED[1]:B RPIN:B RPOUT:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT gcsmx_rebuf CS[0] CS[1] CS[2] CS[3] CSI[0] CSI[1] CSI[2] CSI[3] PWR
+ VDDA VNW VSS
*.PININFO CS[0]:B CS[1]:B CS[2]:B CS[3]:B CSI[0]:B CSI[1]:B CSI[2]:B CSI[3]:B
*.PININFO PWR:B VDDA:B VNW:B VSS:B
XI12[0] VSS VSS CSI[0] net027[0] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[1] VSS VSS CSI[1] net027[1] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[2] VSS VSS CSI[2] net027[2] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[3] VSS VSS CSI[3] net027[3] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI11[0] VSS VSS net027[0] CS[0] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[1] VSS VSS net027[1] CS[1] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[2] VSS VSS net027[2] CS[2] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[3] VSS VSS net027[3] CS[3] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
.ENDS

.SUBCKT grdmx_rebuf BS[0] BS[1] BS[2] BS[3] BSI[0] BSI[1] BSI[2] BSI[3] PWR
+ VDDA VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B BSI[0]:B BSI[1]:B BSI[2]:B BSI[3]:B
*.PININFO PWR:B VDDA:B VNW:B VSS:B
XI12[0] VSS VSS BSI[0] net027[0] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[1] VSS VSS BSI[1] net027[1] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[2] VSS VSS BSI[2] net027[2] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[3] VSS VSS BSI[3] net027[3] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI11[0] VSS VSS net027[0] BS[0] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[1] VSS VSS net027[1] BS[1] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[2] VSS VSS net027[2] BS[2] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[3] VSS VSS net027[3] BS[3] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
.ENDS

.SUBCKT redgio_rebuf BWBR0 BWBR1 DBR0 DBR1 PREOUT PREOUTS PWR RPFEED[0]
+ RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO BWBR0:B BWBR1:B DBR0:B DBR1:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B
*.PININFO RPFEED[1]:B RPIN:B RPOUT:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT nored_gio_edge BWBR0 BWBR1 DBR0 DBR1 PREOUT PREOUTS PWR RPFEED[0]
+ RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO BWBR0:B BWBR1:B DBR0:B DBR1:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B
*.PININFO RPFEED[1]:B RPIN:B RPOUT:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT grdmx4to1 BS[0] BS[1] BS[2] BS[3] GRDB[0] GRDB[1] GRDB[2] GRDB[3] PWR
+ QB VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B GRDB[0]:B GRDB[1]:B GRDB[2]:B
*.PININFO GRDB[3]:B PWR:B QB:B VNW:B VSS:B
XI177 GRDB[0] GRDB[1] BS[1] BS[0] VSS VSS PWR VNW net017 / mux21
XI178 GRDB[2] GRDB[3] BS[3] BS[2] VSS VSS PWR VNW net016 / mux21
XI179 net016 net017 VSS VSS PWR VNW QB / nor2 nm=1 n_w=400n pm=1 p_w=800n
.ENDS

.SUBCKT grdmx4 BS[0] BS[1] BS[2] BS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] PWR QB0 QB1 QB2 QB3 VDDA VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B
*.PININFO GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B
*.PININFO GRD3[2]:B GRD3[3]:B PWR:B QB0:B QB1:B QB2:B QB3:B VDDA:B VNW:B VSS:B
XI0 BS[0] BS[1] BS[2] BS[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR QB0 VNW VSS /
+ grdmx4to1
XI2 BS[0] BS[1] BS[2] BS[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] PWR QB2 VNW VSS /
+ grdmx4to1
XI3 BS[0] BS[1] BS[2] BS[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR QB3 VNW VSS /
+ grdmx4to1
XI1 BS[0] BS[1] BS[2] BS[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR QB1 VNW VSS /
+ grdmx4to1
.ENDS

.SUBCKT gio4 BADIO BWM D LBWM LBWMB LCLKIO LDB LD PREOUTQ PWR Q SWT TBWM TD TE VDDA VNW
+ VSS
*.PININFO BWM:I D:I TBWM:I TD:I Q:O BADIO:B LBWM:B LCLKIO:B LDB:B PREOUTQ:B
*.PININFO PWR:B SWT:B TE:B VDDA:B VNW:B VSS:B
XXGIO BADIO BWM D LBWM LBWMB  LCLKIO LDB LD PREOUTQ PWR Q SWT TBWM TD TE VDDA VNW VSS /
+ gio
.ENDS

.SUBCKT red_gio2 BADIO BWBR0 BWBR1 DBR0 DBR1 GBW GD LBWM LDB PREOUT PREOUTQ
+ PREOUTS PWR RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO GBW:O GD:O PREOUTQ:O BADIO:B BWBR0:B BWBR1:B DBR0:B DBR1:B LBWM:B
*.PININFO LDB:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B RPFEED[1]:B RPIN:B
*.PININFO RPOUT:B VDDA:B VNW:B VSS:B
Xred BADIO BWBR0 BWBR1 DBR0 DBR1 GBW GD LBWM LDB PREOUT PREOUTQ PREOUTS PWR
+ RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS / red_gio
.ENDS

.SUBCKT gcsmx2 CS[0] CS[1] CS[2] CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR Q0 QB0 QB1 VDDA VNW VSS
*.PININFO CS[0]:B CS[1]:B CS[2]:B CS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B
*.PININFO Q0:B QB0:B QB1:B VDDA:B VNW:B VSS:B
XI177 VSS VSS net09 Q0 PWR VNW / inv_svt nm=1 n_w=400n pm=1 p_w=800n
XI175 QB0 QB1 CS[1] CS[0] VSS VSS PWR VNW net09 / mux21
.ENDS

.SUBCKT grdmx2 BS[0] BS[1] BS[2] BS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR QB0 QB1 VDDA VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B
*.PININFO QB0:B QB1:B VDDA:B VNW:B VSS:B
XI0 BS[0] BS[1] BS[2] BS[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR QB0 VNW VSS /
+ grdmx4to1
XI1 BS[0] BS[1] BS[2] BS[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR QB1 VNW VSS /
+ grdmx4to1
.ENDS

.SUBCKT grdmx2_bk2 BS[0] BS[1] BS[2] BS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR QB0 QB1 VDDA VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B
*.PININFO QB0:B QB1:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT gio1 BADIO BWM D LBWM LBWMB LCLKIO LDB LD PREOUTQ PWR Q SWT TBWM TD TE VDDA VNW
+ VSS
*.PININFO BWM:I D:I TBWM:I TD:I Q:O BADIO:B LBWM:B LCLKIO:B LDB:B PREOUTQ:B
*.PININFO PWR:B SWT:B TE:B VDDA:B VNW:B VSS:B
XXGIO BADIO BWM D LBWM LBWMB LCLKIO LDB LD PREOUTQ PWR Q SWT TBWM TD TE VDDA VNW VSS /
+ gio
.ENDS

.SUBCKT red_gio1 BADIO BWBR0 BWBR1 DBR0 DBR1 GBW GD LBWM LDB PREOUT PREOUTQ
+ PREOUTS PWR RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS
*.PININFO GBW:O GD:O PREOUTQ:O BADIO:B BWBR0:B BWBR1:B DBR0:B DBR1:B LBWM:B
*.PININFO LDB:B PREOUT:B PREOUTS:B PWR:B RPFEED[0]:B RPFEED[1]:B RPIN:B
*.PININFO RPOUT:B VDDA:B VNW:B VSS:B
Xred BADIO BWBR0 BWBR1 DBR0 DBR1 GBW GD LBWM LDB PREOUT PREOUTQ PREOUTS PWR
+ RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS / red_gio
.ENDS

.SUBCKT gcsmx1_bk4 CS[0] CS[1] CS[2] CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ PWR Q0 QB0 VDDA VNW VSS
*.PININFO CS[0]:B CS[1]:B CS[2]:B CS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B PWR:B Q0:B QB0:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT gcsmx1 CS[0] CS[1] CS[2] CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ PWR Q0 QB0 VDDA VNW VSS
*.PININFO CS[0]:B CS[1]:B CS[2]:B CS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B PWR:B Q0:B QB0:B VDDA:B VNW:B VSS:B
XI178 VSS VSS QB0 net012 PWR VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI179 VSS VSS net012 Q0 PWR VNW / inv_svt nm=1 n_w=400n pm=1 p_w=800n
.ENDS

.SUBCKT gcsmx1_bk2 CS[0] CS[1] CS[2] CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ PWR Q0 QB0 VDDA VNW VSS
*.PININFO CS[0]:B CS[1]:B CS[2]:B CS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B PWR:B Q0:B QB0:B VDDA:B VNW:B VSS:B
XI178 VSS VSS QB0 net012 PWR VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI179 VSS VSS net012 Q0 PWR VNW / inv_svt nm=1 n_w=400n pm=1 p_w=800n
.ENDS

.SUBCKT grdmx1_bk2 BS[0] BS[1] BS[2] BS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ PWR QB0 VDDA VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B PWR:B QB0:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT grdmx1 BS[0] BS[1] BS[2] BS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ PWR QB0 VDDA VNW VSS
*.PININFO BS[0]:B BS[1]:B BS[2]:B BS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B PWR:B QB0:B VDDA:B VNW:B VSS:B
XI0 BS[0] BS[1] BS[2] BS[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR QB0 VNW VSS /
+ grdmx4to1
.ENDS

.SUBCKT floorplan_gio_red
*.PININFO
XI42 net0612 net0346 net0347 net0497 net0349 net0357 net0351 net0365 net0620
+ net0588 net0356 net0355 net0552 net0362 net0560 net0363 / gio2
XI26 net0148 net0133 net0134 net0238 net0136 net0144 net0138 net0152 net0135
+ net0140 net0143 net0142 net0139 net0149 net0154 net0150 / gio2
XI57 net0686 net0774 net0624 net0818 net0804 net0819 net0592 / gio_edge
XI50 net0731 net0704 net0712 net0730 net0653 net0683 net0721 / gio_edge
XI31 net0243 net012 net0747 net0245 net010 net011 net09 / gio_edge
XI3 net0675 net12 net0633 net0710 net10 net11 net9 / gio_edge
XI39 net0266 net0265 net0508 net0574 net0543 net0269 net0271 net0659 net0493
+ net0263 net0507 net0603 net0270 net0261[0] net0261[1] net0262 net0526
+ net0604 net0272 net0268 / red_gio4
XI29 net0215 net0214 net0209 net0213 net0208 net0218 net0220 net0700 net0203
+ net0212 net0204 net0207 net0219 net0210[0] net0210[1] net0211 net0206
+ net0216 net0221 net0217 / red_gio4
XI40 net0580[0] net0580[1] net0580[2] net0580[3] net0301 net0303 net0836[0]
+ net0836[1] net0836[2] net0836[3] net0785[0] net0785[1] net0785[2] net0785[3]
+ net0861[0] net0861[1] net0861[2] net0861[3] net0857[0] net0857[1] net0857[2]
+ net0857[3] net0577 net0293 net0294 net0296 net0292 net0299 net0297 net0298
+ net0610 / gcsmx4
XI28 net0225[0] net0225[1] net0225[2] net0225[3] net0231 net0233 net0156[0]
+ net0156[1] net0156[2] net0156[3] net0155[0] net0155[1] net0155[2] net0155[3]
+ net0707[0] net0707[1] net0707[2] net0707[3] net0864[0] net0864[1] net0864[2]
+ net0864[3] net0232 net0224 net0226 net0227 net0222 net0223 net0228 net0229
+ net0230 / gcsmx4
XI56 net0194[0] net0194[1] net0194[2] net0194[3] net0651 net0771 net0763
+ net0668 / gcsmx_edge
XI52 net0585[0] net0585[1] net0585[2] net0585[3] net0749 net0696 net0681
+ net0755 / gcsmx_edge
XI55 net0770[0] net0770[1] net0770[2] net0770[3] net0714 net0679 net0619
+ net0205 / grdmx_edge
XI53 net0541[0] net0541[1] net0541[2] net0541[3] net0703 net0706 net0740
+ net0693 / grdmx_edge
XI67 net0163 net0162 net0157 net0918 net0859 net0153 net0151 net0708 net0719
+ net0664  net0158[0] net0158[1] net0159 net0784 net0164 net0926
+ net0165 / nored_gio1
XI63 net0899 net0775 net0939 net0180 net0906 net0892 net0759 net0179 net0174
+ net0932  net0879[0] net0879[1] net0178 net0813 net0723 net0739
+ net0911 / nored_gio1
XI32 net0307 net0317 net0302 net0324 net0341 net032 net0334 net0327 net0264
+ net0331 / gio_rebuf
XI66 net0845 net0858 net0843 net0934 net0713 net0201 net0199 net0888 net0872
+ net0779 net0938 net0800[0] net0800[1] net0922 net0743 net0920 net0936
+ net0750 / nored_gio2
XI62 net0931 net0684 net0908 net0678 net0876 net0769 net0937 net0873 net0807
+ net0838 net0778 net0662[0] net0662[1] net0912 net0916 net0895 net0236
+ net0913 / nored_gio2
XI59 net0941 net0237 net0720 net0889 net0919 net0239 net0244 net0887[0]
+ net0887[1] net0930 net0240 net0241 net0853 net0242 / nored_gio_rebuf
XI65 net0890 net0902 net0921 net0733 net0904 net0815 net0901 net0886 net0897
+ net0698 net0871 net0773[0] net0773[1] net0910 net0687 net0842 net0741
+ net0877 / nored_gio4
XI60 net0281 net0280 net0275 net0279 net0940 net0928 net0725 net0278 net0933
+ net0273 net0285 net0276[0] net0276[1] net0277 net0776 net0865 net0287
+ net0283 / nored_gio4
XI54 net0680 net0823 net0601 net0822 net0791 net0801 net0780 net0658[0]
+ net0658[1] net0821 net0832 net0809 net0722 net0829 / red_gio_edge
XI51 net0566 net0715 net0728 net0760 net0746 net0555 net0661 net0729[0]
+ net0729[1] net0716 net0554 net0689 net0754 net0692 / red_gio_edge
XI34 net014[0] net014[1] net014[2] net014[3] net013[0] net013[1] net013[2]
+ net013[3] net018 net016 net017 net015 / gcsmx_rebuf
XI58 net0837[0] net0837[1] net0837[2] net0837[3] net0599[0] net0599[1]
+ net0599[2] net0599[3] net0234 net0812 net0764 net0757 / grdmx_rebuf
XI35 net04[0] net04[1] net04[2] net04[3] net01[0] net01[1] net01[2] net01[3]
+ net06 net03 net05 net02 / grdmx_rebuf
XI0 net4[0] net4[1] net4[2] net4[3] net1[0] net1[1] net1[2] net1[3] net6 net3
+ net5 net2 / grdmx_rebuf
XI33 net0635 net0753 net056 net0611 net055 net0820 net061 net058[0] net058[1]
+ net054 net0781 net0756 net053 net052 / redgio_rebuf
XI64 net0359 net0354 net0924 net0896 net0718 net0352 net0717 net0833[0]
+ net0833[1] net0758 net0847 net0795 net0826 net0917 / nored_gio_edge
XI61 net0372 net0841 net0929 net0915 net0370 net0893 net0835 net0669[0]
+ net0669[1] net0369 net0806 net0373 net0376 net0935 / nored_gio_edge
XI41 net0320[0] net0320[1] net0320[2] net0320[3] net0607 net0330 net0595[0]
+ net0595[1] net0595[2] net0595[3] net0326[0] net0326[1] net0326[2] net0326[3]
+ net0553[0] net0553[1] net0553[2] net0553[3] net0319[0] net0319[1] net0319[2]
+ net0319[3] net0329 net0581 net0321 net0316 net0325 net0322 net0597 net0501 /
+ grdmx4
XI36 net0250[0] net0250[1] net0250[2] net0250[3] net0258 net0260 net0254[0]
+ net0254[1] net0254[2] net0254[3] net0256[0] net0256[1] net0256[2] net0256[3]
+ net0247[0] net0247[1] net0247[2] net0247[3] net0249[0] net0249[1] net0249[2]
+ net0249[3] net0259 net0248 net0251 net0246 net0255 net0252 net0253 net0257 /
+ grdmx4
XI38 net0449 net0434 net0435 net0671 net0437 net0445 net0439 net0453 net0436
+ net0441 net0444 net0443 net0440 net0450 net0455 net0451 / gio4
XI30 net0196 net0181 net0182 net0682 net0184 net0192 net0186 net0200 net0183
+ net0188 net0191 net0190 net0187 net0197 net0202 net0198 / gio4
XI43 net0576 net0583 net0598 net0485 net0600 net0593 net0548 net0371 net086
+ net0589 net087 net0586 net0531 net0519[0] net0519[1] net0534 net089 net0490
+ net0606 net0528 / red_gio2
XI25 net045 net044 net039 net043 net038 net048 net050 net0282 net033 net042
+ net034 net037 net049 net040[0] net040[1] net041 net036 net046 net051 net047
+ / red_gio2
XI44 net0125[0] net0125[1] net0125[2] net0125[3] net0131 net0510 net0375[0]
+ net0375[1] net0375[2] net0375[3] net0374[0] net0374[1] net0374[2] net0374[3]
+ net0132 net0480 net0126 net0127 net0128 net0129 net0130 / gcsmx2
XI24 net0120[0] net0120[1] net0120[2] net0120[3] net0122 net0124 net0387[0]
+ net0387[1] net0387[2] net0387[3] net0386[0] net0386[1] net0386[2] net0386[3]
+ net0123 net0160 net0117 net0161 net0118 net0119 net0121 / gcsmx2
XI45 net0481[0] net0481[1] net0481[2] net0481[3] net0516 net0533 net0489[0]
+ net0489[1] net0489[2] net0489[3] net0572[0] net0572[1] net0572[2] net0572[3]
+ net0623 net0605 net0602 net0591 net0509 net0594 / grdmx2
XI23 net092[0] net092[1] net092[2] net092[3] net096 net098 net091[0] net091[1]
+ net091[2] net091[3] net0170[0] net0170[1] net0170[2] net0170[3] net097
+ net090 net0171 net093 net094 net095 / grdmx2
XI46 net0527 net0166 net0167 net0411 net0169 net0177 net0616 net0540 net0168
+ net0173 net0176 net0175 net0172 net0590 net0584 net0504 / gio1
XI37 net0364 net0384 net0393 net0396 net0323 net0389 net0385 net0109 net0392
+ net0380 net0333 net0300 net0295 net0366 net0111 net0336 / gio1
XI12 net139 net124 net125 net0512 net127 net135 net129 net143 net126 net131
+ net134 net133 net130 net140 net145 net141 / gio1
XI5 net0105 net0360 net0368 net0419 net0353 net0101 net0361 net106 net0367
+ net0358 net0100 net099 net0274 net102 net103 net104 / gio1
XI47 net026 net025 net020 net024 net019 net029 net0562 net0433 net0618 net023
+ net0563 net0617 net030 net021[0] net021[1] net022 net0622 net027 net0571
+ net028 / red_gio1
XI11 net45 net44 net39 net43 net38 net48 net50 net0406 net33 net42 net34 net37
+ net49 net40[0] net40[1] net41 net36 net46 net51 net47 / red_gio1
XI48 net0502[0] net0502[1] net0502[2] net0502[3] net057 net0621 net0951[0]
+ net0951[1] net0951[2] net0951[3] net0550 net0875 net0613 net0499 net0567 /
+ gcsmx1
XI10 net111[0] net111[1] net111[2] net111[3] net113 net115 net0959[0]
+ net0959[1] net0959[2] net0959[3] net114 net0891 net109 net110 net112 / gcsmx1
XI49 net070[0] net070[1] net070[2] net070[3] net074 net076 net069[0] net069[1]
+ net069[2] net069[3] net075 net068 net071 net072 net073 / grdmx1
XI9 net92[0] net92[1] net92[2] net92[3] net96 net98 net91[0] net91[1] net91[2]
+ net91[3] net97 net90 net93 net94 net95 / grdmx1
.ENDS

.SUBCKT globlat_adr A CB CT PWR QB QT VDDP VSS
*.PININFO A:I CB:I CT:I QB:O QT:O PWR:B VDDP:B VSS:B
XI16 VDDP PWR QT net032 / pch nf=1 w=240n m=1
XI17 VDDP net032 CT QB / pch nf=1 w=240n m=1
XI21 A CT CB VSS VSS PWR VDDP QB / tri_svt nm=1 n_w=480n pm=1 p_w=800n
XI14 VSS VSS QB QT PWR VDDP / inv_svt nm=1 n_w=480n pm=1 p_w=800n
XI18 VSS QB CB net023 / nch nf=1 w=240n m=1
XI19 VSS net023 QT VSS / nch nf=1 w=240n m=1
.ENDS

.SUBCKT bist_adr_lat A CB CT NTE PWR QB QT TA TE VNW VSS
*.PININFO A:I CB:I CT:I NTE:I TA:I TE:I QB:O QT:O PWR:B VNW:B VSS:B
XI21 A TA TE NTE VSS VSS PWR VNW DB / mux21
Xxmaster DB CB CT PWR QB QT VNW VSS / globlat_adr
.ENDS

.SUBCKT nor3 A B C G Gb P Pb Y
*.PININFO A:I B:I C:I Y:O G:B Gb:B P:B Pb:B
XN0 Gb Y A G / nch nf=1 w=n_w m=nm
XN2 Gb Y C G / nch nf=1 w=n_w m=nm
XN1 Gb Y B G / nch nf=1 w=n_w m=nm
XP2 Pb P C net19 / pch nf=1 w=p_w m=pm
XP0 Pb net019 A Y / pch nf=1 w=p_w m=pm
XP1 Pb net19 B net019 / pch nf=1 w=p_w m=pm
.ENDS

.SUBCKT rm0detect EN ENB HN PWR RA RDYB RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2]
+ SD SL SWT SYNCWT SZ VDDA VNW VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3]
+ VSB[4] VSS WM[0] WM[1] WM[2] WMO[0] WMO[1] WMO[2] ag_ctrl
*.PININFO RA:I EN:O ENB:O RMO[0]:O RMO[1]:O RMO[2]:O WMO[0]:O WMO[1]:O
*.PININFO WMO[2]:O HN:B PWR:B RDYB:B RM[0]:B RM[1]:B RM[2]:B SD:B SL:B SWT:B
*.PININFO SYNCWT:B SZ:B VDDA:B VNW:B VSB100:B VSB200:B VSB300:B VSB400:B VSB[1]:B
*.PININFO VSB[2]:B VSB[3]:B VSB[4]:B VSS:B WM[0]:B WM[1]:B WM[2]:B ag_ctrl:B
XD1 SYNCWT VSS / ant_diode nf=1 w=240nm m=1
XD14[0] VSB100 VSS / ant_diode nf=1 w=240nm m=1
XD14[1] VSB200 VSS / ant_diode nf=1 w=240nm m=1
XD14[2] VSB300 VSS / ant_diode nf=1 w=240nm m=1
XD14[3] VSB400 VSS / ant_diode nf=1 w=240nm m=1
XD13 HN VSS / ant_diode nf=1 w=240nm m=1
XD2 SZ VSS / ant_diode nf=1 w=240nm m=1
XD12 SD VSS / ant_diode nf=1 w=240nm m=1
XD3 SL VSS / ant_diode nf=1 w=240nm m=1
XD5[0] RM[0] VSS / ant_diode nf=1 w=240nm m=1
XD5[1] RM[1] VSS / ant_diode nf=1 w=240nm m=1
XD5[2] RM[2] VSS / ant_diode nf=1 w=240nm m=1
XD0[0] WM[0] VSS / ant_diode nf=1 w=240nm m=1
XD0[1] WM[1] VSS / ant_diode nf=1 w=240nm m=1
XD0[2] WM[2] VSS / ant_diode nf=1 w=240nm m=1
XD16 RA VSS / ant_diode nf=1 w=240nm m=1
XI41 SD HN SZ VSS VSS VDDA VNW net067 / nor3 pm=1 p_w=720n nm=1 n_w=360n
XI44 VSS VSS SL net051 VDDA VNW / inv pm=1 p_w=540n nm=1 n_w=360n
XI34 VSS VSS SYNCWT net048 PWR VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI33 VSS VSS net048 SWT PWR VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI431 VSS VSS SD net074 VDDA VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI433[0] VSS VSS net072[0] VSB[1] VDDA VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI433[1] VSS VSS net072[1] VSB[2] VDDA VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI433[2] VSS VSS net072[2] VSB[3] VDDA VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI433[3] VSS VSS net072[3] VSB[4] VDDA VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI35 VSS VSS ag_ctrl_n ag_ctrl VDDA VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI428 VSS VSS net067 ag_ctrl_n VDDA VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI437 VSS VSS RA ENB PWR VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI436 VSS VSS ENB EN PWR VNW / inv pm=2 p_w=720n nm=2 n_w=480n
XI22[0] VSS VSS net017[0] WMO[0] PWR VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI22[1] VSS VSS net017[1] WMO[1] PWR VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI22[2] VSS VSS net017[2] WMO[2] PWR VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI31[0] VSS VSS net016[0] RMO[0] PWR VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI31[1] VSS VSS net016[1] RMO[1] PWR VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI31[2] VSS VSS net016[2] RMO[2] PWR VNW / inv pm=1 p_w=720n nm=1 n_w=480n
XI19[0] VSS VSS WM[0] net017[0] PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI19[1] VSS VSS WM[1] net017[1] PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI19[2] VSS VSS WM[2] net017[2] PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI5[0] VSS VSS RM[0] net016[0] PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI5[1] VSS VSS RM[1] net016[1] PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI5[2] VSS VSS RM[2] net016[2] PWR VNW / inv pm=1 p_w=360n nm=1 n_w=240n
XI45 net067 net051 VSS VSS VDDA VNW RDYB / nand2 pm=1 p_w=720n nm=1 n_w=960n
XI432[0] VSB100 net074 VSS VSS VDDA VNW net072[0] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI432[1] VSB200 net074 VSS VSS VDDA VNW net072[1] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI432[2] VSB300 net074 VSS VSS VDDA VNW net072[2] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI432[3] VSB400 net074 VSS VSS VDDA VNW net072[3] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
.ENDS

.SUBCKT stat_xnor A0 A0_b A0p A0p_b PWR VNW VSS result
*.PININFO A0:I A0_b:I A0p:I A0p_b:I PWR:B VNW:B VSS:B result:B
XI8 VSS net014 A0p_b VSS / nch_lvtx nf=1 w=480n m=1
XI7 VSS net015 A0p VSS / nch_lvtx nf=1 w=480n m=1
XI6 VSS result A0 net014 / nch_lvtx nf=1 w=480n m=1
XI5 VSS result A0_b net015 / nch_lvtx nf=1 w=480n m=1
XI10 VNW net020 A0 result / pch_lvtx nf=1 w=720n m=1
XI12 VNW PWR A0p net020 / pch_lvtx nf=1 w=720n m=1
XI11 VNW net019 A0_b result / pch_lvtx nf=1 w=720n m=1
XI13 VNW PWR A0p_b net019 / pch_lvtx nf=1 w=720n m=1
.ENDS

.SUBCKT bist_adr_latcmp A CB CT EQ NTE PWR QT SB ST TA TE VNW VSS
*.PININFO A:I CB:I CT:I NTE:I SB:I ST:I TA:I TE:I EQ:O QT:O PWR:B VNW:B VSS:B
XI21 A TA TE NTE VSS VSS PWR VNW D / mux21
XI23 QT net022 net20 net020 PWR VNW VSS EQ / stat_xnor
Xxslave QT ST SB PWR net020 net20 VNW VSS / globlat_adr
Xxmaster D CB CT PWR net022 QT VNW VSS / globlat_adr
.ENDS

.SUBCKT cgen CLK MEMCKB NTE RSTB TCLK TE VDDA VNW VSS
*.PININFO CLK:I NTE:I RSTB:I TCLK:I TE:I MEMCKB:O VDDA:B VNW:B VSS:B
XI5 VSS net033 RSTB VSS / nch_lvtx nf=1 w=1.14u m=3
XI7 VSS MEMCKB KEEP net033 / nch_lvtx nf=1 w=240n m=1
XI22 VSS net17 TE net033 / nch_lvtx nf=1 w=1.14u m=3
XI4 VSS net35 NTE net033 / nch_lvtx nf=1 w=1.14u m=3
XI0 VSS MEMCKB CLK net35 / nch_lvtx nf=1 w=1.14u m=3
XI23 VSS MEMCKB TCLK net17 / nch_lvtx nf=1 w=1.14u m=3
XI21 VSS VSS MEMCKB KEEP VDDA VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI26 VNW VDDA KEEP net021 / pch_lvtx nf=1 w=360n m=1
XI25 VNW net021 TCLK MEMCKB / pch_lvtx nf=1 w=360n m=1
XI24 VNW net021 TE MEMCKB / pch_lvtx nf=1 w=360n m=1
XI11 VNW VDDA RSTB MEMCKB / pch_lvtx nf=1 w=720n m=3
XI6 VNW VDDA KEEP net032 / pch_lvtx nf=1 w=360n m=1
XI1 VNW net032 CLK MEMCKB / pch_lvtx nf=1 w=360n m=1
XI10 VNW net032 NTE MEMCKB / pch_lvtx nf=1 w=360n m=1
.ENDS

.SUBCKT txgate E EB Gb IN OUT Pb
*.PININFO E:I EB:I IN:I OUT:O Gb:B Pb:B
XP0 Pb OUT EB IN / pch nf=1 w=p_w m=pm
XN0 Gb IN E OUT / nch nf=1 w=n_w m=nm
.ENDS

.SUBCKT lat A CB CT PWR QB QT VDDP VSS
*.PININFO A:I CB:I CT:I QB:O QT:O PWR:B VDDP:B VSS:B
XI16 VDDP PWR QB net032 / pch nf=1 w=240n m=1
XI17 VDDP net032 CT net020 / pch nf=1 w=240n m=1
XI18 VSS net020 CB net023 / nch nf=1 w=240n m=1
XI19 VSS net023 QB VSS / nch nf=1 w=240n m=1
XI11 CT CB VSS A net020 VDDP / txgate nm=1 n_w=360n pm=1 p_w=360n
XI14 VSS VSS net020 QB PWR VDDP / inv pm=1 p_w=360n nm=1 n_w=240n
XI15 VSS VSS QB QT PWR VDDP / inv pm=1 p_w=360n nm=1 n_w=240n
.ENDS

.SUBCKT nand2_lvt A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XN0 Gb Y A net10 / nch_lvt nf=1 w=n_w m=nm
XN1 Gb net10 B G / nch_lvt nf=1 w=n_w m=nm
XP0 Pb P A Y / pch_lvt nf=1 w=p_w m=pm
XP1 Pb P B Y / pch_lvt nf=1 w=p_w m=pm
.ENDS

.SUBCKT nor2_lvt A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XP1 Pb P B net12 / pch_lvt nf=1 w=p_w m=pm
XP0 Pb net12 A Y / pch_lvt nf=1 w=p_w m=pm
XN0 Gb Y A G / nch_lvt nf=1 w=n_w m=nm
XN1 Gb Y B G / nch_lvt nf=1 w=n_w m=nm
.ENDS

.SUBCKT clockgen2 CE CLK LCLK LCLKB LCLKIO NTE PWR RDYB RST RWCLK SCLK SCLKB
+ T1EN TCE TCLK TE TEST1 VDDA VNW VSS
*.PININFO CE:I CLK:I NTE:I RDYB:I RST:I TCE:I TCLK:I TE:I TEST1:I LCLK:O
*.PININFO LCLKB:O LCLKIO:O RWCLK:O SCLK:O SCLKB:O T1EN:O PWR:B VDDA:B VNW:B
*.PININFO VSS:B
XXCGEN CLK MEMCKB LCENTANE RSTB TCLK LCENTATE VDDA VNW VSS / cgen
XI47 CENT CT CB PWR LCENB LCENT VNW VSS / lat
XI102 CLK TCLK TE NTE VSS net078 PWR net079 CT / mux21
XI104 CE TCE TE NTE VSS net076 PWR net077 CENT / mux21
XI170 MEMCKB LCENT net072 VSS VSS PWR VNW LCKP / nand3_lvt pm=1 p_w=360n nm=1
+ n_w=480n
XI169 VSS VSS RDYB net072 PWR VNW / inv_lvt pm=1 p_w=480n nm=1 n_w=360n
XI92 VSS VSS net052 T1EN PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI240 VSS VSS net035 LCLKIO PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI108 VSS VSS CT CB PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI231 VSS VSS LCLKB LCLK PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI98 VSS VSS SCLKB SCLK PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI50 VSS VSS net031 RSTB PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI91 VSS VSS LCKP LCLKB PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI168 VSS VSS MEMCKB RWCLK PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI97 VSS VSS RWCLK SCLKB PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI158 VSS VSS LCKP net035 PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI312 TEST1 CLK VSS VSS PWR VNW net052 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI51 CT net031 VSS VSS PWR VNW net044 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI49 SLPRSTB net044 VSS VSS VDDA VNW net031 / nand2 pm=1 p_w=720n nm=1 n_w=720n
XI135 LCENB TE VSS VSS PWR VNW LCENTANE / nor2_lvt nm=1 n_w=240n pm=1 p_w=620n
XI167 LCENB NTE VSS VSS PWR VNW LCENTATE / nor2_lvt nm=1 n_w=240n pm=1 p_w=620n
XI96 RST RDYB VSS VSS VDDA VNW SLPRSTB / nor2 nm=1 n_w=240n pm=1 p_w=720n
.ENDS

.SUBCKT dly_svt G Gb IN OUT P Pb
*.PININFO IN:I OUT:O G:B Gb:B P:B Pb:B
XI11 Pb P IN net010 / pch nf=p_f w=p_w m=1
XI7 Pb net010 IN OUT / pch nf=p_f w=p_w m=1
XI10 Gb net011 IN G / nch nf=n_f w=n_w m=1
XI4 Gb OUT IN net011 / nch nf=n_f w=n_w m=1
.ENDS

.SUBCKT col_dec2to4 A0 A1 PWR VNW VSS X[0] X[1] X[2] X[3]
*.PININFO A0:I A1:I X[0]:O X[1]:O X[2]:O X[3]:O PWR:B VNW:B VSS:B
XI17 VSS VSS A0 A0B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI10 VSS VSS net057 X[2] PWR VNW / inv_lvt pm=4 p_w=720n nm=4 n_w=480n
XI41 VSS VSS net058 X[3] PWR VNW / inv_lvt pm=4 p_w=720n nm=4 n_w=480n
XI12 VSS VSS net056 X[1] PWR VNW / inv_lvt pm=4 p_w=720n nm=4 n_w=480n
XI18 VSS VSS A1 A1B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI11 VSS VSS net059 X[0] PWR VNW / inv_lvt pm=4 p_w=720n nm=4 n_w=480n
XI14 A1 A0B VSS VSS PWR VNW net057 / nand2 pm=1 p_w=720n nm=1 n_w=720n
XI13 A1 A0 VSS VSS PWR VNW net058 / nand2 pm=1 p_w=720n nm=1 n_w=720n
XI15 A1B A0 VSS VSS PWR VNW net056 / nand2 pm=1 p_w=720n nm=1 n_w=720n
XI16 A1B A0B VSS VSS PWR VNW net059 / nand2 pm=1 p_w=720n nm=1 n_w=720n
.ENDS

.SUBCKT half_lat A CB CT PWR QB VNW VSS
*.PININFO A:I CB:I CT:I QB:O PWR:B VNW:B VSS:B
XI11 CB CT VSS A DT VNW / txgate nm=1 n_w=240n pm=1 p_w=360n
XI18 VSS DT CT net023 / nch_lvtx nf=1 w=240n m=1
XI19 VSS net023 QB VSS / nch_lvtx nf=1 w=240n m=1
XI21 VSS VSS DT QB PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI16 VNW PWR QB net032 / pch_lvtx nf=1 w=240n m=1
XI17 VNW net032 CB DT / pch_lvtx nf=1 w=240n m=1
.ENDS

.SUBCKT nand3 A B C G Gb P Pb Y
*.PININFO A:I B:I C:I Y:O G:B Gb:B P:B Pb:B
XN0 Gb Y A net15 / nch nf=1 w=n_w m=nm
XN2 Gb net14 C G / nch nf=1 w=n_w m=nm
XN1 Gb net15 B net14 / nch nf=1 w=n_w m=nm
XP2 Pb P C Y / pch nf=1 w=p_w m=pm
XP1 Pb P B Y / pch nf=1 w=p_w m=pm
XP0 Pb P A Y / pch nf=1 w=p_w m=pm
.ENDS

.SUBCKT nor2_lvtx A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XN0 Gb Y A G / nch_lvtx nf=1 w=n_w m=nm
XN1 Gb Y B G / nch_lvtx nf=1 w=n_w m=nm
XP1 Pb P B net12 / pch_lvtx nf=1 w=p_w m=pm
XP0 Pb net12 A Y / pch_lvtx nf=1 w=p_w m=pm
.ENDS

.SUBCKT half_lat_set A CB CT PWR QB SET VNW VSS
*.PININFO A:I CB:I CT:I SET:I QB:O PWR:B VNW:B VSS:B
XI22 DT SET VSS VSS PWR VNW QB / nor2_lvtx pm=1 p_w=360n nm=1 n_w=240n
XI18 VSS DT CT net023 / nch_lvtx nf=1 w=240n m=1
XI19 VSS net023 QB VSS / nch_lvtx nf=1 w=240n m=1
XI16 VNW PWR QB net032 / pch_lvtx nf=1 w=240n m=1
XI17 VNW net032 CB DT / pch_lvtx nf=1 w=240n m=1
XI11 CB CT VSS A DT VNW / txgate nm=1 n_w=240n pm=1 p_w=360n
.ENDS

.SUBCKT cmpy1 ADRXR[0] ADRXR[1] ADRXR[2] ADRXR[3] ADRXR[4] ADRXR[5] ADRXR[6]
+ ADRXR[7] ADRXR[8] ADRXR[9] ADRXR[10] ADRXR[11] CSH_HT CSH_LD HN LCACHE_EN
+ LWE PWR RWCLK SCLK SCLKB T1EN VDDA VNW VSS
*.PININFO ADRXR[0]:I ADRXR[1]:I ADRXR[2]:I ADRXR[3]:I ADRXR[4]:I ADRXR[5]:I
*.PININFO ADRXR[6]:I ADRXR[7]:I ADRXR[8]:I ADRXR[9]:I ADRXR[10]:I ADRXR[11]:I
*.PININFO HN:I LCACHE_EN:I LWE:I RWCLK:I SCLK:I SCLKB:I T1EN:I CSH_HT:O
*.PININFO CSH_LD:O PWR:B VDDA:B VNW:B VSS:B
XI50 VSS VSS VALID INVAL PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI54 VNW VDDA HT_MISSB LD_MISSB / pch_lvtx nf=1 w=360n m=1
XI11 VNW VDDA RWCLK LD_MISSB / pch_lvtx nf=1 w=480n m=2
XI53 VSS VSS LD_MISSB CSH_LD PWR VNW / inv_lvtx nm=3 n_w=360n pm=3 p_w=720n
XI18 LCACHE_EN LWE VSS VSS PWR VNW INVAL_CUR / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI194 z[0] SCLKB SCLK PWR NXT_INVAL VNW VSS / half_lat
XI92 VSS VSS RWCLK net049 VDDA VNW / dly_svt n_w=180n n_f=1 p_w=180n p_f=1
XI91 VSS VSS net049 rwclkd VDDA VNW / dly_svt n_w=180n n_f=1 p_w=180n p_f=1
XI90 RWCLK rwclkd LD_MISSB VSS VSS VDDA VNW HT_MISSB / nand3 pm=1 p_w=360n
+ nm=1 n_w=480n
XI89 ADRXR[2] ADRXR[0] ADRXR[1] VSS VSS PWR VNW z0 / nand3 pm=1 p_w=720n nm=1
+ n_w=720n
XI86 ADRXR[11] ADRXR[10] ADRXR[9] VSS VSS PWR VNW z3 / nand3 pm=1 p_w=720n
+ nm=1 n_w=720n
XI88 ADRXR[5] ADRXR[4] ADRXR[3] VSS VSS PWR VNW z1 / nand3 pm=1 p_w=720n nm=1
+ n_w=720n
XI87 ADRXR[8] ADRXR[7] ADRXR[6] VSS VSS PWR VNW z2 / nand3 pm=1 p_w=720n nm=1
+ n_w=720n
XI193 INVAL_CUR SCLK SCLKB PWR z[0] HN VNW VSS / half_lat_set
XI56 VSS net058 RWCLK VSS / nch_lvtx nf=1 w=480n m=2
XI57[0] VSS LD_MISSB z0 net058 / nch_lvtx nf=1 w=960n m=1
XI57[1] VSS LD_MISSB z1 net058 / nch_lvtx nf=1 w=960n m=1
XI57[2] VSS LD_MISSB z2 net058 / nch_lvtx nf=1 w=960n m=1
XI57[3] VSS LD_MISSB z3 net058 / nch_lvtx nf=1 w=960n m=1
XI57[4] VSS LD_MISSB INVAL net058 / nch_lvtx nf=1 w=960n m=1
XI64 VSS LD_MISSB CSH_LD net058 / nch_lvtx nf=1 w=240n m=1
XI74 HT_MISSB T1EN VSS VSS PWR VNW CSH_HT / nor2 nm=1 n_w=240n pm=1 p_w=720n
XI12 INVAL_CUR NXT_INVAL VSS VSS PWR VNW VALID / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
.ENDS

.SUBCKT nand3_lvtx A B C G Gb P Pb Y
*.PININFO A:I B:I C:I Y:O G:B Gb:B P:B Pb:B
XP2 Pb P C Y / pch_lvtx nf=1 w=p_w m=pm
XP1 Pb P B Y / pch_lvtx nf=1 w=p_w m=pm
XP0 Pb P A Y / pch_lvtx nf=1 w=p_w m=pm
XN0 Gb Y A net15 / nch_lvtx nf=1 w=n_w m=nm
XN2 Gb net014 C G / nch_lvtx nf=1 w=n_w m=nm
XN1 Gb net15 B net014 / nch_lvtx nf=1 w=n_w m=nm
.ENDS

.SUBCKT dec2to4 A0 A1 PWR VNW VSS X[0] X[1] X[2] X[3]
*.PININFO A0:I A1:I X[0]:O X[1]:O X[2]:O X[3]:O PWR:B VNW:B VSS:B
XI17 VSS VSS A0 A0B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI10 VSS VSS net057 X[2] PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI41 VSS VSS net058 X[3] PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI12 VSS VSS net056 X[1] PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI18 VSS VSS A1 A1B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI11 VSS VSS net059 X[0] PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI14 A1 A0B VSS VSS PWR VNW net057 / nand2 pm=2 p_w=720n nm=2 n_w=720n
XI13 A1 A0 VSS VSS PWR VNW net058 / nand2 pm=2 p_w=720n nm=2 n_w=720n
XI15 A1B A0 VSS VSS PWR VNW net056 / nand2 pm=2 p_w=720n nm=2 n_w=720n
XI16 A1B A0B VSS VSS PWR VNW net059 / nand2 pm=2 p_w=720n nm=2 n_w=720n
.ENDS

.SUBCKT strobe_ctl_b_lvt A0 A1 CB CT PWR VNW VSS Y[0] Y[1] Y[2] Y[3]
*.PININFO A0:B A1:B CB:B CT:B PWR:B VNW:B VSS:B Y[0]:B Y[1]:B Y[2]:B Y[3]:B
XI18 A0 CT CB PWR net014 LA0 VNW VSS / globlat_adr
XI19 A1 CT CB PWR net013 LA1 VNW VSS / globlat_adr
XDEC LA0 LA1 PWR VNW VSS Y[0] Y[1] Y[2] Y[3] / dec2to4
.ENDS

.SUBCKT gioctl_cs CS[0] CS[1] CS[2] CS[3] LLRSTB LRD LRST PWR QT[0] QT[1]
+ RWCLK VNW VSS
*.PININFO CS[0]:O CS[1]:O CS[2]:O CS[3]:O LLRSTB:B LRD:B LRST:B PWR:B QT[0]:B
*.PININFO QT[1]:B RWCLK:B VNW:B VSS:B
XI421 RWCLK LRD LRST VSS VSS PWR VNW LLRSTB / nand3_lvtx nm=1 n_w=690n pm=1
+ p_w=720n
XI0 VSS VSS LLRSTB LLRST PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XGIOCS QT[0] QT[1] LLRST LLRSTB PWR VNW VSS CS[0] CS[1] CS[2] CS[3] /
+ strobe_ctl_b_lvt
.ENDS

.SUBCKT gctl_cache_base A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9]
+ A[10] A[11] A[12] A[13] AWT BISTE BK[0] BK[1] BPUI BWBR CACHE_EN CACHE_MISS
+ CE CLK CS[0] CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1]
+ CSH_YS[2] CSH_YS[3] DBR EN ENB GRST HN LCLKIO LLRSTB PREOUT PWR QT[2] QT[3]
+ QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RA RM[0]
+ RM[1] RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT SZ T1EN
+ TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10] TA[11]
+ TA[12] TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW VSB100
+ VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1] WM[2]
+ WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I A[8]:I
*.PININFO A[9]:I A[10]:I A[11]:I A[12]:I A[13]:I CE:I CLK:I GRST:I RA:I
*.PININFO RM[0]:I RM[1]:I RM[2]:I TA[0]:I TA[1]:I TA[2]:I TA[3]:I TA[4]:I
*.PININFO TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I TA[11]:I TA[12]:I
*.PININFO TA[13]:I TCE:I TCLK:I TEST1:I TWE:I WE:I WM[0]:I WM[1]:I WM[2]:I
*.PININFO CACHE_MISS:O CS[0]:O CS[1]:O CS[2]:O CS[3]:O CSH_ENB:O CSH_LD:O
*.PININFO CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O CSH_YS[2]:O CSH_YS[3]:O EN:O ENB:O
*.PININFO LCLKIO:O LLRSTB:O QT[2]:O QT[3]:O QT[4]:O QT[5]:O QT[6]:O QT[7]:O
*.PININFO QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O QT[13]:O RMO[0]:O
*.PININFO RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O WMO[2]:O ZRR:O
*.PININFO AWT:B BISTE:B BK[0]:B BK[1]:B BPUI:B BWBR:B CACHE_EN:B DBR:B HN:B
*.PININFO PREOUT:B PWR:B RPIN:B RRMATCH:B SD:B SL:B SPUI:B SWT:B SZ:B TCACHE_EN:B
*.PININFO TE:B TRRMATCH:B VDDA:B VNW:B VSB100:B VSB200:B VSB300:B VSB400:B
*.PININFO VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B ag_ctrl:B
XI475 CACHE_EN LCLK LCLKB net0118 PWR net094 CSH_EN TCACHE_EN TE VNW VSS /
+ bist_adr_lat
XXRW RRMATCH LCLK LCLKB net0118 PWR ZRRB ZRR TRRMATCH TE VNW VSS / bist_adr_lat
XXL1 A[1] LCLK LCLKB net0118 PWR QB[1] QT[1] TA[1] TE VNW VSS / bist_adr_lat
XXL0 A[0] LCLK LCLKB net0118 PWR QB[0] QT[0] TA[0] TE VNW VSS / bist_adr_lat
XXRRLAT WE LCLK LCLKB net0118 PWR LWEB RWOUT TWE TE VNW VSS / bist_adr_lat
Xi0 EN ENB HN PWR RA RDYB RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] SD SL SWT AWT
+ SZ VDDA VNW VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WM[0]
+ WM[1] WM[2] WMO[0] WMO[1] WMO[2] ag_ctrl / rm0detect
XXL3 A[3] LCLK LCLKB ADDXR[3] net0118 PWR QT[3] SCLK SCLKB TA[3] TE VNW VSS /
+ bist_adr_latcmp
XXL2 A[2] LCLK LCLKB ADDXR[2] net0118 PWR QT[2] SCLK SCLKB TA[2] TE VNW VSS /
+ bist_adr_latcmp
XXL4 A[4] LCLK LCLKB ADDXR[4] net0118 PWR QT[4] SCLK SCLKB TA[4] TE VNW VSS /
+ bist_adr_latcmp
XXL5 A[5] LCLK LCLKB ADDXR[5] net0118 PWR QT[5] SCLK SCLKB TA[5] TE VNW VSS /
+ bist_adr_latcmp
XXL7 A[7] LCLK LCLKB ADDXR[7] net0118 PWR QT[7] SCLK SCLKB TA[7] TE VNW VSS /
+ bist_adr_latcmp
XXL6 A[6] LCLK LCLKB ADDXR[6] net0118 PWR QT[6] SCLK SCLKB TA[6] TE VNW VSS /
+ bist_adr_latcmp
XXL8 A[8] LCLK LCLKB ADDXR[8] net0118 PWR QT[8] SCLK SCLKB TA[8] TE VNW VSS /
+ bist_adr_latcmp
XXL9 A[9] LCLK LCLKB ADDXR[9] net0118 PWR QT[9] SCLK SCLKB TA[9] TE VNW VSS /
+ bist_adr_latcmp
XXL11 A[11] LCLK LCLKB ADDXR[11] net0118 PWR QT[11] SCLK SCLKB TA[11] TE VNW
+ VSS / bist_adr_latcmp
XXL10 A[10] LCLK LCLKB ADDXR[10] net0118 PWR QT[10] SCLK SCLKB TA[10] TE VNW
+ VSS / bist_adr_latcmp
XXL12 A[12] LCLK LCLKB ADDXR[12] net0118 PWR QT[12] SCLK SCLKB TA[12] TE VNW
+ VSS / bist_adr_latcmp
XXL13 A[13] LCLK LCLKB ADDXR[13] net0118 PWR QT[13] SCLK SCLKB TA[13] TE VNW
+ VSS / bist_adr_latcmp
XXCLKGEN CE CLK LCLK LCLKB LCLKIO net0118 PWR RDYB LRST RWCLK SCLK SCLKB T1EN
+ TCE TCLK TE TEST1 VDDA VNW VSS / clockgen2
XI91 VSS VSS net088 net087 VDDA VNW / dly_svt n_w=180n n_f=1 p_w=180n p_f=1
XI92 VSS VSS CSH_RD net088 VDDA VNW / dly_svt n_w=180n n_f=1 p_w=180n p_f=1
XI50 QT[0] QT[1] PWR VNW VSS CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] /
+ col_dec2to4
XD26 CE VSS / ant_diode nf=1 w=240nm m=1
XD20 BISTE VSS / ant_diode nf=1 w=240nm m=1
XD24 TCLK VSS / ant_diode nf=1 w=240nm m=1
XD2 TCACHE_EN VSS / ant_diode nf=1 w=240nm m=1
XD0[0] TA[0] VSS / ant_diode nf=1 w=240nm m=1
XD0[1] TA[1] VSS / ant_diode nf=1 w=240nm m=1
XD0[2] TA[2] VSS / ant_diode nf=1 w=240nm m=1
XD0[3] TA[3] VSS / ant_diode nf=1 w=240nm m=1
XD0[4] TA[4] VSS / ant_diode nf=1 w=240nm m=1
XD0[5] TA[5] VSS / ant_diode nf=1 w=240nm m=1
XD0[6] TA[6] VSS / ant_diode nf=1 w=240nm m=1
XD0[7] TA[7] VSS / ant_diode nf=1 w=240nm m=1
XD0[8] TA[8] VSS / ant_diode nf=1 w=240nm m=1
XD0[9] TA[9] VSS / ant_diode nf=1 w=240nm m=1
XD0[10] TA[10] VSS / ant_diode nf=1 w=240nm m=1
XD0[11] TA[11] VSS / ant_diode nf=1 w=240nm m=1
XD0[12] TA[12] VSS / ant_diode nf=1 w=240nm m=1
XD0[13] TA[13] VSS / ant_diode nf=1 w=240nm m=1
XD1 WE VSS / ant_diode nf=1 w=240nm m=1
XD3 CACHE_EN VSS / ant_diode nf=1 w=240nm m=1
XD30 TRRMATCH VSS / ant_diode nf=1 w=240nm m=1
XD23 CLK VSS / ant_diode nf=1 w=240nm m=1
XD31 RRMATCH VSS / ant_diode nf=1 w=240nm m=1
XD21 TWE VSS / ant_diode nf=1 w=240nm m=1
XD22 TEST1 VSS / ant_diode nf=1 w=240nm m=1
XD17[0] A[0] VSS / ant_diode nf=1 w=240nm m=1
XD17[1] A[1] VSS / ant_diode nf=1 w=240nm m=1
XD17[2] A[2] VSS / ant_diode nf=1 w=240nm m=1
XD17[3] A[3] VSS / ant_diode nf=1 w=240nm m=1
XD17[4] A[4] VSS / ant_diode nf=1 w=240nm m=1
XD17[5] A[5] VSS / ant_diode nf=1 w=240nm m=1
XD17[6] A[6] VSS / ant_diode nf=1 w=240nm m=1
XD17[7] A[7] VSS / ant_diode nf=1 w=240nm m=1
XD17[8] A[8] VSS / ant_diode nf=1 w=240nm m=1
XD17[9] A[9] VSS / ant_diode nf=1 w=240nm m=1
XD17[10] A[10] VSS / ant_diode nf=1 w=240nm m=1
XD17[11] A[11] VSS / ant_diode nf=1 w=240nm m=1
XD17[12] A[12] VSS / ant_diode nf=1 w=240nm m=1
XD17[13] A[13] VSS / ant_diode nf=1 w=240nm m=1
XD25 TCE VSS / ant_diode nf=1 w=240nm m=1
XI18 GRST net080 VSS VSS PWR VNW LRST / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI474 ADDXR[2] ADDXR[3] ADDXR[4] ADDXR[5] ADDXR[6] ADDXR[7] ADDXR[8] ADDXR[9]
+ ADDXR[10] ADDXR[11] ADDXR[12] ADDXR[13] CSH_RD CSH_LD_INT HN CSH_EN LWEB PWR
+ RWCLK SCLK SCLKB T1EN VDDA VNW VSS / cmpy1
XI480 CSH_LD_INT LWEB VSS VSS VDDA VNW net095 / nand2_lvt pm=1 p_w=360n nm=1
+ n_w=480n
XI469 CSH_LD_INT ZRR VSS VSS VDDA VNW net0107 / nand2_lvt pm=1 p_w=720n nm=1
+ n_w=480n
XI434 CSH_LD_INT ZRRB VSS VSS VDDA VNW net085 / nand2_lvt pm=2 p_w=720n nm=2
+ n_w=480n
XI477 VSS VSS CSH_EN CSH_ENB PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI200 VSS VSS net095 CACHE_MISS VDDA VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI435 VSS VSS net085 CSH_LD PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI468 VSS VSS net0107 CSH_RR PWR VNW / inv_lvt pm=4 p_w=720n nm=4 n_w=480n
Xgioctl CS[0] CS[1] CS[2] CS[3] LLRSTB LWEB LRST PWR QT[0] QT[1] RWCLK VNW VSS
+ / gioctl_cs
XI478 VSS VSS net087 net080 VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI441 VSS VSS net0118 TE PWR VNW / inv_svt nm=1 n_w=480n pm=1 p_w=720n
XI442 VSS VSS BISTE net0118 PWR VNW / inv_svt nm=1 n_w=480n pm=1 p_w=720n
.ENDS

.SUBCKT gctl_cache_cm8 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10]
+ A[11] A[12] A[13] AWT BISTE BK[0] BK[1] BPUI BS[0] BS[1] BS[2] BS[3] BWBR
+ CACHE_EN CACHE_MISS CE CLK CS[0] CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR
+ CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBR EN ENB GRST HN LCLKIO PREOUT PWR
+ QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+ RA RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT
+ SZ T1EN TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10]
+ TA[11] TA[12] TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW
+ VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1]
+ WM[2] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I A[8]:I
*.PININFO A[9]:I A[10]:I A[11]:I A[12]:I A[13]:I CE:I CLK:I GRST:I RA:I
*.PININFO RM[0]:I RM[1]:I RM[2]:I TA[0]:I TA[1]:I TA[2]:I TA[3]:I TA[4]:I
*.PININFO TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I TA[11]:I TA[12]:I
*.PININFO TA[13]:I TCE:I TCLK:I TEST1:I TWE:I WE:I WM[0]:I WM[1]:I WM[2]:I
*.PININFO BS[0]:O BS[1]:O BS[2]:O BS[3]:O CACHE_MISS:O CS[0]:O CS[1]:O CS[2]:O
*.PININFO CS[3]:O CSH_ENB:O CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O
*.PININFO CSH_YS[2]:O CSH_YS[3]:O EN:O ENB:O LCLKIO:O QT[2]:O QT[3]:O QT[4]:O
*.PININFO QT[5]:O QT[6]:O QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O
*.PININFO QT[13]:O RMO[0]:O RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O
*.PININFO WMO[2]:O ZRR:O AWT:B BISTE:B BK[0]:B BK[1]:B BPUI:B BWBR:B
*.PININFO CACHE_EN:B DBR:B HN:B PREOUT:B PWR:B RPIN:B RRMATCH:B SD:B SL:B
*.PININFO SPUI:B SWT:B SZ:B TCACHE_EN:B TE:B TRRMATCH:B VDDA:B VNW:B VSB100:B
*.PININFO VSB200:B VSB300:B VSB400:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B
*.PININFO ag_ctrl:B
XI481 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12]
+ A[13] AWT BISTE net059 net058 BPUI BWBR CACHE_EN CACHE_MISS CE CLK CS[0]
+ CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBR EN ENB GRST HN LCLKIO net060 PREOUT PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RA RM[0] RM[1]
+ RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT SZ T1EN TA[0]
+ TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10] TA[11] TA[12]
+ TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW VSB100 VSB200
+ VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1] WM[2] WMO[0]
+ WMO[1] WMO[2] ZRR ag_ctrl / gctl_cache_base
.ENDS

.SUBCKT gioctl_bs BS[0] BS[1] BS[2] BS[3] LLRSTB PWR QT[12] QT[13] VNW VSS
*.PININFO BS[0]:O BS[1]:O BS[2]:O BS[3]:O LLRSTB:B PWR:B QT[12]:B QT[13]:B
*.PININFO VNW:B VSS:B
XI381 VSS VSS LLRSTB LLRST PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XGIOBS QT[12] QT[13] LLRST LLRSTB PWR VNW VSS BS[0] BS[1] BS[2] BS[3] /
+ strobe_ctl_b_lvt
.ENDS

.SUBCKT gctl_cache_cm4_bk A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9]
+ A[10] A[11] A[12] A[13] AWT BISTE BK[0] BK[1] BPUI BS[0] BS[1] BS[2] BS[3]
+ BWBR CACHE_EN CACHE_MISS CE CLK CS[0] CS[1] CS[2] CS[3] CSH_ENB CSH_LD
+ CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBR EN ENB GRST HN LCLKIO
+ PREOUT PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RA RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT
+ SD SL SPUI SWT SZ T1EN TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8]
+ TA[9] TA[10] TA[11] TA[12] TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE
+ VDDA VNW VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE
+ WM[0] WM[1] WM[2] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I A[8]:I
*.PININFO A[9]:I A[10]:I A[11]:I A[12]:I A[13]:I CE:I CLK:I GRST:I RA:I
*.PININFO RM[0]:I RM[1]:I RM[2]:I TA[0]:I TA[1]:I TA[2]:I TA[3]:I TA[4]:I
*.PININFO TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I TA[11]:I TA[12]:I
*.PININFO TA[13]:I TCE:I TCLK:I TEST1:I TWE:I WE:I WM[0]:I WM[1]:I WM[2]:I
*.PININFO BS[0]:O BS[1]:O BS[2]:O BS[3]:O CACHE_MISS:O CS[0]:O CS[1]:O CS[2]:O
*.PININFO CS[3]:O CSH_ENB:O CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O
*.PININFO CSH_YS[2]:O CSH_YS[3]:O EN:O ENB:O LCLKIO:O QT[2]:O QT[3]:O QT[4]:O
*.PININFO QT[5]:O QT[6]:O QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O
*.PININFO QT[13]:O RMO[0]:O RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O
*.PININFO WMO[2]:O ZRR:O AWT:B BISTE:B BK[0]:B BK[1]:B BPUI:B BWBR:B
*.PININFO CACHE_EN:B DBR:B HN:B PREOUT:B PWR:B RPIN:B RRMATCH:B SD:B SL:B
*.PININFO SPUI:B SWT:B SZ:B TCACHE_EN:B TE:B TRRMATCH:B VDDA:B VNW:B VSB100:B
*.PININFO VSB200:B VSB300:B VSB400:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B
*.PININFO ag_ctrl:B
XI481 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12]
+ A[13] AWT BISTE net059 net058 BPUI BWBR CACHE_EN CACHE_MISS CE CLK CS[0]
+ CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBR EN ENB GRST HN LCLKIO net060 PREOUT PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RA RM[0] RM[1]
+ RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT SZ T1EN TA[0]
+ TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10] TA[11] TA[12]
+ TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW VSB100 VSB200
+ VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1] WM[2] WMO[0]
+ WMO[1] WMO[2] ZRR ag_ctrl / gctl_cache_base
XI488 BS[0] BS[1] BS[2] BS[3] net060 PWR BK[0] BK[1] VNW VSS / gioctl_bs
.ENDS

.SUBCKT gioctl BS[0] BS[1] BS[2] BS[3] CS[0] CS[1] CS[2] CS[3] LRD LRST PWR
+ QT[0] QT[1] QT[12] QT[13] RWCLK VNW VSS
*.PININFO BS[0]:O BS[1]:O BS[2]:O BS[3]:O CS[0]:O CS[1]:O CS[2]:O CS[3]:O
*.PININFO LRD:B LRST:B PWR:B QT[0]:B QT[1]:B QT[12]:B QT[13]:B RWCLK:B VNW:B
*.PININFO VSS:B
XI421 RWCLK LRD LRST VSS VSS PWR VNW LLRSTB / nand3_lvtx nm=1 n_w=690n pm=1
+ p_w=720n
XI0 VSS VSS LLRSTB net016 PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI381 VSS VSS LLRSTB LLRST PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XGIOBS QT[12] QT[13] LLRST LLRSTB PWR VNW VSS BS[0] BS[1] BS[2] BS[3] /
+ strobe_ctl_b_lvt
XGIOCS QT[0] QT[1] net016 LLRSTB PWR VNW VSS CS[0] CS[1] CS[2] CS[3] /
+ strobe_ctl_b_lvt
.ENDS

.SUBCKT gctl_cache A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10]
+ A[11] A[12] A[13] AWT BISTE BK[0] BK[1] BPUI BS[0] BS[1] BS[2] BS[3] BWBR
+ CACHE_EN CACHE_MISS CE CLK CS[0] CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR
+ CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBR EN ENB GRST HN LCLKIO PREOUT PWR
+ QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+ RA RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT
+ T1EN TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10]
+ TA[11] TA[12] TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW
+ VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1]
+ WM[2] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I A[8]:I
*.PININFO A[9]:I A[10]:I A[11]:I A[12]:I A[13]:I CE:I CLK:I GRST:I RA:I
*.PININFO RM[0]:I RM[1]:I RM[2]:I TA[0]:I TA[1]:I TA[2]:I TA[3]:I TA[4]:I
*.PININFO TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I TA[11]:I TA[12]:I
*.PININFO TA[13]:I TCE:I TCLK:I TEST1:I TWE:I WE:I WM[0]:I WM[1]:I WM[2]:I
*.PININFO BS[0]:O BS[1]:O BS[2]:O BS[3]:O CACHE_MISS:O CS[0]:O CS[1]:O CS[2]:O
*.PININFO CS[3]:O CSH_ENB:O CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O
*.PININFO CSH_YS[2]:O CSH_YS[3]:O EN:O ENB:O LCLKIO:O QT[2]:O QT[3]:O QT[4]:O
*.PININFO QT[5]:O QT[6]:O QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O
*.PININFO QT[13]:O RMO[0]:O RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O
*.PININFO WMO[2]:O ZRR:O AWT:B BISTE:B BK[0]:B BK[1]:B BPUI:B BWBR:B
*.PININFO CACHE_EN:B DBR:B HN:B PREOUT:B PWR:B RPIN:B RRMATCH:B SD:B SL:B
*.PININFO SPUI:B SWT:B TCACHE_EN:B TE:B TRRMATCH:B VDDA:B VNW:B VSB100:B
*.PININFO VSB200:B VSB300:B VSB400:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B
*.PININFO ag_ctrl:B
XI475 CACHE_EN LCLK LCLKB net0118 PWR net094 CSH_EN TCACHE_EN TE VNW VSS /
+ bist_adr_lat
XXRW RRMATCH LCLK LCLKB net0118 PWR ZRRB ZRR TRRMATCH TE VNW VSS / bist_adr_lat
XXL1 A[1] LCLK LCLKB net0118 PWR QB[1] QT[1] TA[1] TE VNW VSS / bist_adr_lat
XXL0 A[0] LCLK LCLKB net0118 PWR QB[0] QT[0] TA[0] TE VNW VSS / bist_adr_lat
XXRRLAT WE LCLK LCLKB net0118 PWR LWEB RWOUT TWE TE VNW VSS / bist_adr_lat
Xi0 EN ENB HN PWR RA RDYB RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] SD SL SWT AWT
+ VDDA VNW VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WM[0]
+ WM[1] WM[2] WMO[0] WMO[1] WMO[2] ag_ctrl / rm0detect
Xgioctl BS[0] BS[1] BS[2] BS[3] CS[0] CS[1] CS[2] CS[3] LWEB LRST PWR QT[0]
+ QT[1] BK[0] BK[1] RWCLK VNW VSS / gioctl
XXL3 A[3] LCLK LCLKB ADDXR[3] net0118 PWR QT[3] SCLK SCLKB TA[3] TE VNW VSS /
+ bist_adr_latcmp
XXL2 A[2] LCLK LCLKB ADDXR[2] net0118 PWR QT[2] SCLK SCLKB TA[2] TE VNW VSS /
+ bist_adr_latcmp
XXL4 A[4] LCLK LCLKB ADDXR[4] net0118 PWR QT[4] SCLK SCLKB TA[4] TE VNW VSS /
+ bist_adr_latcmp
XXL5 A[5] LCLK LCLKB ADDXR[5] net0118 PWR QT[5] SCLK SCLKB TA[5] TE VNW VSS /
+ bist_adr_latcmp
XXL7 A[7] LCLK LCLKB ADDXR[7] net0118 PWR QT[7] SCLK SCLKB TA[7] TE VNW VSS /
+ bist_adr_latcmp
XXL6 A[6] LCLK LCLKB ADDXR[6] net0118 PWR QT[6] SCLK SCLKB TA[6] TE VNW VSS /
+ bist_adr_latcmp
XXL8 A[8] LCLK LCLKB ADDXR[8] net0118 PWR QT[8] SCLK SCLKB TA[8] TE VNW VSS /
+ bist_adr_latcmp
XXL9 A[9] LCLK LCLKB ADDXR[9] net0118 PWR QT[9] SCLK SCLKB TA[9] TE VNW VSS /
+ bist_adr_latcmp
XXL11 A[11] LCLK LCLKB ADDXR[11] net0118 PWR QT[11] SCLK SCLKB TA[11] TE VNW
+ VSS / bist_adr_latcmp
XXL10 A[10] LCLK LCLKB ADDXR[10] net0118 PWR QT[10] SCLK SCLKB TA[10] TE VNW
+ VSS / bist_adr_latcmp
XXL12 A[12] LCLK LCLKB ADDXR[12] net0118 PWR QT[12] SCLK SCLKB TA[12] TE VNW
+ VSS / bist_adr_latcmp
XXL13 A[13] LCLK LCLKB ADDXR[13] net0118 PWR QT[13] SCLK SCLKB TA[13] TE VNW
+ VSS / bist_adr_latcmp
XXCLKGEN CE CLK LCLK LCLKB LCLKIO net0118 PWR RDYB LRST RWCLK SCLK SCLKB T1EN
+ TCE TCLK TE TEST1 VDDA VNW VSS / clockgen2
XI91 VSS VSS net088 net087 VDDA VNW / dly_svt n_w=180n n_f=1 p_w=180n p_f=1
XI92 VSS VSS CSH_RD net088 VDDA VNW / dly_svt n_w=180n n_f=1 p_w=180n p_f=1
XI50 QT[0] QT[1] PWR VNW VSS CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] /
+ col_dec2to4
XD26 CE VSS / ant_diode nf=1 w=240nm m=1
XD20 BISTE VSS / ant_diode nf=1 w=240nm m=1
XD24 TCLK VSS / ant_diode nf=1 w=240nm m=1
XD2 TCACHE_EN VSS / ant_diode nf=1 w=240nm m=1
XD0[0] TA[0] VSS / ant_diode nf=1 w=240nm m=1
XD0[1] TA[1] VSS / ant_diode nf=1 w=240nm m=1
XD0[2] TA[2] VSS / ant_diode nf=1 w=240nm m=1
XD0[3] TA[3] VSS / ant_diode nf=1 w=240nm m=1
XD0[4] TA[4] VSS / ant_diode nf=1 w=240nm m=1
XD0[5] TA[5] VSS / ant_diode nf=1 w=240nm m=1
XD0[6] TA[6] VSS / ant_diode nf=1 w=240nm m=1
XD0[7] TA[7] VSS / ant_diode nf=1 w=240nm m=1
XD0[8] TA[8] VSS / ant_diode nf=1 w=240nm m=1
XD0[9] TA[9] VSS / ant_diode nf=1 w=240nm m=1
XD0[10] TA[10] VSS / ant_diode nf=1 w=240nm m=1
XD0[11] TA[11] VSS / ant_diode nf=1 w=240nm m=1
XD0[12] TA[12] VSS / ant_diode nf=1 w=240nm m=1
XD0[13] TA[13] VSS / ant_diode nf=1 w=240nm m=1
XD1 WE VSS / ant_diode nf=1 w=240nm m=1
XD3 CACHE_EN VSS / ant_diode nf=1 w=240nm m=1
XD30 TRRMATCH VSS / ant_diode nf=1 w=240nm m=1
XD23 CLK VSS / ant_diode nf=1 w=240nm m=1
XD31 RRMATCH VSS / ant_diode nf=1 w=240nm m=1
XD21 TWE VSS / ant_diode nf=1 w=240nm m=1
XD22 TEST1 VSS / ant_diode nf=1 w=240nm m=1
XD17[0] A[0] VSS / ant_diode nf=1 w=240nm m=1
XD17[1] A[1] VSS / ant_diode nf=1 w=240nm m=1
XD17[2] A[2] VSS / ant_diode nf=1 w=240nm m=1
XD17[3] A[3] VSS / ant_diode nf=1 w=240nm m=1
XD17[4] A[4] VSS / ant_diode nf=1 w=240nm m=1
XD17[5] A[5] VSS / ant_diode nf=1 w=240nm m=1
XD17[6] A[6] VSS / ant_diode nf=1 w=240nm m=1
XD17[7] A[7] VSS / ant_diode nf=1 w=240nm m=1
XD17[8] A[8] VSS / ant_diode nf=1 w=240nm m=1
XD17[9] A[9] VSS / ant_diode nf=1 w=240nm m=1
XD17[10] A[10] VSS / ant_diode nf=1 w=240nm m=1
XD17[11] A[11] VSS / ant_diode nf=1 w=240nm m=1
XD17[12] A[12] VSS / ant_diode nf=1 w=240nm m=1
XD17[13] A[13] VSS / ant_diode nf=1 w=240nm m=1
XD25 TCE VSS / ant_diode nf=1 w=240nm m=1
XI18 GRST net080 VSS VSS PWR VNW LRST / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI474 ADDXR[2] ADDXR[3] ADDXR[4] ADDXR[5] ADDXR[6] ADDXR[7] ADDXR[8] ADDXR[9]
+ ADDXR[10] ADDXR[11] ADDXR[12] ADDXR[13] CSH_RD CSH_LD_INT HN CSH_EN LWEB PWR
+ RWCLK SCLK SCLKB T1EN VDDA VNW VSS / cmpy1
XI480 CSH_LD_INT LWEB VSS VSS VDDA VNW net095 / nand2_lvt pm=1 p_w=360n nm=1
+ n_w=480n
XI469 CSH_LD_INT ZRR VSS VSS VDDA VNW net0107 / nand2_lvt pm=1 p_w=720n nm=1
+ n_w=480n
XI434 CSH_LD_INT ZRRB VSS VSS VDDA VNW net085 / nand2_lvt pm=2 p_w=720n nm=2
+ n_w=480n
XI477 VSS VSS CSH_EN CSH_ENB PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI200 VSS VSS net095 CACHE_MISS VDDA VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI435 VSS VSS net085 CSH_LD PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI468 VSS VSS net0107 CSH_RR PWR VNW / inv_lvt pm=4 p_w=720n nm=4 n_w=480n
XI478 VSS VSS net087 net080 VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI441 VSS VSS net0118 TE PWR VNW / inv_svt nm=1 n_w=480n pm=1 p_w=720n
XI442 VSS VSS BISTE net0118 PWR VNW / inv_svt nm=1 n_w=480n pm=1 p_w=720n
.ENDS

.SUBCKT gctl_cache_cm8_bk A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9]
+ A[10] A[11] A[12] A[13] AWT BISTE BK[0] BK[1] BPUI BS[0] BS[1] BS[2] BS[3]
+ BWBR CACHE_EN CACHE_MISS CE CLK CS[0] CS[1] CS[2] CS[3] CSH_ENB CSH_LD
+ CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBR EN ENB GRST HN LCLKIO
+ PREOUT PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RA RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT
+ SD SL SPUI SWT SZ T1EN TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8]
+ TA[9] TA[10] TA[11] TA[12] TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE
+ VDDA VNW VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE
+ WM[0] WM[1] WM[2] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I A[8]:I
*.PININFO A[9]:I A[10]:I A[11]:I A[12]:I A[13]:I CE:I CLK:I GRST:I RA:I
*.PININFO RM[0]:I RM[1]:I RM[2]:I TA[0]:I TA[1]:I TA[2]:I TA[3]:I TA[4]:I
*.PININFO TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I TA[11]:I TA[12]:I
*.PININFO TA[13]:I TCE:I TCLK:I TEST1:I TWE:I WE:I WM[0]:I WM[1]:I WM[2]:I
*.PININFO BS[0]:O BS[1]:O BS[2]:O BS[3]:O CACHE_MISS:O CS[0]:O CS[1]:O CS[2]:O
*.PININFO CS[3]:O CSH_ENB:O CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O
*.PININFO CSH_YS[2]:O CSH_YS[3]:O EN:O ENB:O LCLKIO:O QT[2]:O QT[3]:O QT[4]:O
*.PININFO QT[5]:O QT[6]:O QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O
*.PININFO QT[13]:O RMO[0]:O RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O
*.PININFO WMO[2]:O ZRR:O AWT:B BISTE:B BK[0]:B BK[1]:B BPUI:B BWBR:B
*.PININFO CACHE_EN:B DBR:B HN:B PREOUT:B PWR:B RPIN:B RRMATCH:B SD:B SL:B
*.PININFO SPUI:B SWT:B SZ:B TCACHE_EN:B TE:B TRRMATCH:B VDDA:B VNW:B VSB100:B
*.PININFO VSB200:B VSB300:B VSB400:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B
*.PININFO ag_ctrl:B
XI481 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12]
+ A[13] AWT BISTE net059 net058 BPUI BWBR CACHE_EN CACHE_MISS CE CLK CS[0]
+ CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBR EN ENB GRST HN LCLKIO net060 PREOUT PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RA RM[0] RM[1]
+ RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT SZ T1EN TA[0]
+ TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10] TA[11] TA[12]
+ TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW VSB100 VSB200
+ VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1] WM[2] WMO[0]
+ WMO[1] WMO[2] ZRR ag_ctrl / gctl_cache_base
XI488 BS[0] BS[1] BS[2] BS[3] net060 PWR BK[0] BK[1] VNW VSS / gioctl_bs
.ENDS

.SUBCKT gctl_gcsmx BPUI CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ EN ENB GRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+ QT[11] QT[12] QT[13] RMO[0] RMO[1] RMO[2] RWOUT SPUI T1EN VSB[1] VSB[2]
+ VSB[3] VSB[4] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO GRST:I CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O CSH_YS[2]:O
*.PININFO CSH_YS[3]:O EN:O ENB:O QT[2]:O QT[3]:O QT[4]:O QT[5]:O QT[6]:O
*.PININFO QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O QT[13]:O RMO[0]:O
*.PININFO RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O WMO[2]:O ZRR:O
*.PININFO BPUI:B PWR:B SPUI:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B ag_ctrl:B
.ENDS

.SUBCKT xdec_edge BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBL1 EN ENB GRST LCLKB LXA[0] LXA[1] LXA[2] LXA[3] LXB[0] LXB[1]
+ LXB[2] LXB[3] LXC[0] LXC[1] LXC[2] LXC[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3]
+ PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+ QT[13] RM[0] RM[1] RM[2] RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3]
+ VSB[4] VSS WM[0] WM[1] WM[2] ZRR ag_ctrl
*.PININFO BPUI:B CSH_ENB:B CSH_LD:B CSH_RR:B CSH_YS[0]:B CSH_YS[1]:B
*.PININFO CSH_YS[2]:B CSH_YS[3]:B DBL1:B EN:B ENB:B GRST:B LCLKB:B LXA[0]:B
*.PININFO LXA[1]:B LXA[2]:B LXA[3]:B LXB[0]:B LXB[1]:B LXB[2]:B LXB[3]:B
*.PININFO LXC[0]:B LXC[1]:B LXC[2]:B LXC[3]:B LXWB[0]:B LXWB[1]:B LXWB[2]:B
*.PININFO LXWB[3]:B PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B
*.PININFO QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B RM[0]:B RM[1]:B
*.PININFO RM[2]:B RWOUT:B SPUI:B T1EN:B VDDA:B VNW:B VSB[1]:B VSB[2]:B
*.PININFO VSB[3]:B VSB[4]:B VSS:B WM[0]:B WM[1]:B WM[2]:B ZRR:B ag_ctrl:B
.ENDS

.SUBCKT wldriver_base COM EN ENB PWR VDDA VNW VSS WCH WLR WLSEL
*.PININFO EN:I ENB:I PWR:I WCH:I WLSEL:I WLR:O COM:B VDDA:B VNW:B VSS:B
XI37 VSS net044 EN WLR / nch_svtx nf=1 w=300n m=1
XI105 VSS VSS net026 WLR PWR VNW / inv_lvt pm=8 p_w=960n nm=4 n_w=960n
XI23 VSS VSS WCH WCK PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI21 VNW VDDA WCK net026 / pch_lvtx nf=1 w=480n m=3
XI30 VNW PWR WLSEL COM / pch_lvtx nf=1 w=600n m=1
XI35 VSS net044 ENB VSS / nch_lvtx nf=1 w=300n m=1
XI18 VSS COM WLSEL VSS / nch_lvtx nf=1 w=600n m=1
XI20 VSS net026 WCK COM / nch_lvtx nf=1 w=480n m=3
XI36 VSS WLR net044 VSS / nch_lvtx nf=1 w=600n m=1
.ENDS

.SUBCKT local_tmr_bitcell1 BPUI CSH_ENB CSH_LD CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBL DBL1 EN ENB LCLKB PD[0] PD[1] PD[2] PD[3] PWR QT[2] QT[3]
+ QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1]
+ RM[2] RWL RWLD RWOUT SPUI T1EN VDDA VNW VSS VSSX WM[0] WM[1] WM[2] ag_ctrl
*.PININFO LCLKB:I BPUI:B CSH_ENB:B CSH_LD:B CSH_YS[0]:B CSH_YS[1]:B
*.PININFO CSH_YS[2]:B CSH_YS[3]:B DBL:B DBL1:B EN:B ENB:B PD[0]:B PD[1]:B
*.PININFO PD[2]:B PD[3]:B PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B
*.PININFO QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B RM[0]:B
*.PININFO RM[1]:B RM[2]:B RWL:B RWLD:B RWOUT:B SPUI:B T1EN:B VDDA:B VNW:B
*.PININFO VSS:B VSSX:B WM[0]:B WM[1]:B WM[2]:B ag_ctrl:B
XIND1 RWLB LCLKT VSS VSS net067 VNW net027 / nand2 pm=2 p_w=960n nm=2 n_w=960n
XI152[0] VSS VSS RM[0] RMI[0] PWR VNW / inv_svtx nm=1 n_w=240n pm=1 p_w=360n
XI152[1] VSS VSS RM[1] RMI[1] PWR VNW / inv_svtx nm=1 n_w=240n pm=1 p_w=360n
XI152[2] VSS VSS RM[2] RMI[2] PWR VNW / inv_svtx nm=1 n_w=240n pm=1 p_w=360n
Xxdrv3 VSS EN ENB PWR VDDA VNW VSS DBL_DELAY RWL VDDA / wldriver_base
XI160 VSS VSS net027 PD[3] / nch_svtx nf=1 w=480n m=4
XI155 VSS PD[3] PRM[3] DBL / nch_svtx nf=1 w=480n m=3
XI158 VSS VSS net027 PD[1] / nch_svtx nf=1 w=480n m=4
XI182 VSS VSS net031 net027 / nch_svtx nf=1 w=240n m=1
XI156 VSS PD[0] PRM[0] DBL / nch_svtx nf=1 w=480n m=3
XI154 VSS PD[2] PRM[2] DBL / nch_svtx nf=1 w=480n m=3
XI153 VSS PD[1] PRM[1] DBL / nch_svtx nf=1 w=480n m=3
XI157 VSS VSS net027 PD[0] / nch_svtx nf=1 w=480n m=4
XI159 VSS VSS net027 PD[2] / nch_svtx nf=1 w=480n m=4
XI171 VSS VSS LCLKT net061 VDDA VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI165 VSS VSS RWLD DBL1 VDDA VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI172 VSS VSS DBL net065 net071 VNW / inv_lvt pm=1 p_w=240n nm=1 n_w=240n
XI170 VSS VSS net061 net060 VDDA VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI163 VSS VSS LCLKB LCLKT PWR VNW / inv_lvt pm=1 p_w=1080n nm=2 n_w=360n
XI179 VSS VSS net066 net040 net076 VNW / inv_lvt pm=1 p_w=240n nm=1 n_w=240n
XIIV1 VSS VSS RWL RWLB PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI169 VSS VSS net060 net046 VDDA VNW / inv_lvt pm=2 p_w=360n nm=2 n_w=240n
XI174 net059 VSS net065 net066 VDDA VNW / inv_lvt pm=1 p_w=240n nm=1 n_w=240n
XI181 VSS VSS ag_ctrl net031 VDDA VNW / inv_lvt pm=1 p_w=480n nm=1 n_w=360n
XI177 net077 VSS net040 DBL_DELAY VDDA VNW / inv_lvt pm=1 p_w=240n nm=1
+ n_w=240n
XI162 VNW DBL LCLKT VDDA / pch_lvt nf=1 w=720n m=2
XI183 VNW PWR net031 net067 / pch_lvt nf=1 w=500n m=4
XI175 VDDA net071 DBL VDDA / pch_lvt nf=1 w=240n m=1
XI178 VDDA net076 net066 VDDA / pch_lvt nf=1 w=240n m=1
XI176 VSS net059 net065 VSS / nch_lvt nf=1 w=240n m=1
XI180 VSS net077 net040 VSS / nch_lvt nf=1 w=240n m=1
XI245[0] net046 VSS VSS VSS PWR VNW PRM[0] / nor2_lvt nm=1 n_w=240n pm=1
+ p_w=480n
XI245[1] net046 RMI[0] VSS VSS PWR VNW PRM[1] / nor2_lvt nm=1 n_w=240n pm=1
+ p_w=480n
XI245[2] net046 RMI[1] VSS VSS PWR VNW PRM[2] / nor2_lvt nm=1 n_w=240n pm=1
+ p_w=480n
XI245[3] net046 RMI[2] VSS VSS PWR VNW PRM[3] / nor2_lvt nm=1 n_w=240n pm=1
+ p_w=480n
.ENDS

.SUBCKT wldriverx4 EN ENB LCLKB LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR VDDA VNW
+ VSS WL[0] WL[1] WL[2] WL[3] WSEL
*.PININFO LXWB[0]:I LXWB[1]:I LXWB[2]:I LXWB[3]:I WL[0]:O WL[1]:O WL[2]:O
*.PININFO WL[3]:O EN:B ENB:B LCLKB:B PWR:B VDDA:B VNW:B VSS:B WSEL:B
Xxdrv3 wlsel EN ENB PWR VDDA VNW VSS LXWB[3] WL[3] WSEL / wldriver_base
Xxdrv2 net018 EN ENB PWR VDDA VNW VSS LXWB[2] WL[2] WSEL / wldriver_base
Xxdrv0 net018 EN ENB PWR VDDA VNW VSS LXWB[0] WL[0] WSEL / wldriver_base
Xxdrv1 wlsel EN ENB PWR VDDA VNW VSS LXWB[1] WL[1] WSEL / wldriver_base
XI38 VSS VSS LCLKB net020 PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
.ENDS

.SUBCKT xdecrr BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] EN ENB GRST LCLKB LXA[0] LXA[1] LXA[2] LXA[3] LXB[0] LXB[1] LXB[2]
+ LXB[3] LXC[0] LXC[1] LXC[2] LXC[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2]
+ QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0]
+ RM[1] RM[2] RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WL[0]
+ WL[1] WL[2] WL[3] WM[0] WM[1] WM[2] ZRR ag_ctrl
*.PININFO BPUI:B CSH_ENB:B CSH_LD:B CSH_RR:B CSH_YS[0]:B CSH_YS[1]:B
*.PININFO CSH_YS[2]:B CSH_YS[3]:B EN:B ENB:B GRST:B LCLKB:B LXA[0]:B LXA[1]:B
*.PININFO LXA[2]:B LXA[3]:B LXB[0]:B LXB[1]:B LXB[2]:B LXB[3]:B LXC[0]:B
*.PININFO LXC[1]:B LXC[2]:B LXC[3]:B LXWB[0]:B LXWB[1]:B LXWB[2]:B LXWB[3]:B
*.PININFO PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B
*.PININFO QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B RM[0]:B RM[1]:B RM[2]:B
*.PININFO RWOUT:B SPUI:B T1EN:B VDDA:B VNW:B VSB[1]:B VSB[2]:B VSB[3]:B
*.PININFO VSB[4]:B VSS:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WM[0]:B WM[1]:B
*.PININFO WM[2]:B ZRR:B ag_ctrl:B
XXWLDV EN ENB LCLKB LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR VDDA VNW VSS WL[0]
+ WL[1] WL[2] WL[3] ZRR / wldriverx4
.ENDS

.SUBCKT lsb_dec LSB_XAR MSB_XAR PWR VNW VSS WORD_SEL
*.PININFO LSB_XAR:I MSB_XAR:I WORD_SEL:O PWR:B VNW:B VSS:B
XI4 MSB_XAR net8 VSS VSS PWR VNW WORD_SEL / nor2 nm=1 n_w=240n pm=1 p_w=720n
XI34 VSS VSS LSB_XAR net8 PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
.ENDS

.SUBCKT msb_dec ARA PWR VNW VSS XARA0 XARA1
*.PININFO XARA0:I XARA1:I ARA:O PWR:B VNW:B VSS:B
XI1 XARA1 XARA0 VSS VSS PWR VNW ARA / nand2 pm=1 p_w=360n nm=1 n_w=480n
.ENDS

.SUBCKT xdec BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBL1 EN ENB GRST LCLKB LXA[0] LXA[1] LXA[2] LXA[3] LXB[0] LXB[1]
+ LXB[2] LXB[3] LXC[0] LXC[1] LXC[2] LXC[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3]
+ PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+ QT[13] RM[0] RM[1] RM[2] RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3]
+ VSB[4] VSS WL[0] WL[1] WL[2] WL[3] WM[0] WM[1] WM[2] XARLSBA XARMSBA XARMSBB
+ ZRR ag_ctrl
*.PININFO XARLSBA:I XARMSBA:I XARMSBB:I BPUI:B CSH_ENB:B CSH_LD:B CSH_RR:B
*.PININFO CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B DBL1:B EN:B ENB:B
*.PININFO GRST:B LCLKB:B LXA[0]:B LXA[1]:B LXA[2]:B LXA[3]:B LXB[0]:B LXB[1]:B
*.PININFO LXB[2]:B LXB[3]:B LXC[0]:B LXC[1]:B LXC[2]:B LXC[3]:B LXWB[0]:B
*.PININFO LXWB[1]:B LXWB[2]:B LXWB[3]:B PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B
*.PININFO QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B
*.PININFO RM[0]:B RM[1]:B RM[2]:B RWOUT:B SPUI:B T1EN:B VDDA:B VNW:B VSB[1]:B
*.PININFO VSB[2]:B VSB[3]:B VSB[4]:B VSS:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.PININFO WM[0]:B WM[1]:B WM[2]:B ZRR:B ag_ctrl:B
XI23 XARLSBA net24 PWR VNW VSS WSEL / lsb_dec
XXWLDV EN ENB LCLKB LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR VDDA VNW VSS WL[0]
+ WL[1] WL[2] WL[3] WSEL / wldriverx4
XI22 net24 PWR VNW VSS XARMSBA XARMSBB / msb_dec
.ENDS

.SUBCKT xdec_feedthru BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBL1 EN ENB GRST LCLKB LXA[0] LXA[1] LXA[2] LXA[3] LXB[0] LXB[1]
+ LXB[2] LXB[3] LXC[0] LXC[1] LXC[2] LXC[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3]
+ PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+ QT[13] RM[0] RM[1] RM[2] RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3]
+ VSB[4] VSS WM[0] WM[1] WM[2] ZRR ag_ctrl
*.PININFO BPUI:B CSH_ENB:B CSH_LD:B CSH_RR:B CSH_YS[0]:B CSH_YS[1]:B
*.PININFO CSH_YS[2]:B CSH_YS[3]:B DBL1:B EN:B ENB:B GRST:B LCLKB:B LXA[0]:B
*.PININFO LXA[1]:B LXA[2]:B LXA[3]:B LXB[0]:B LXB[1]:B LXB[2]:B LXB[3]:B
*.PININFO LXC[0]:B LXC[1]:B LXC[2]:B LXC[3]:B LXWB[0]:B LXWB[1]:B LXWB[2]:B
*.PININFO LXWB[3]:B PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B
*.PININFO QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B RM[0]:B RM[1]:B
*.PININFO RM[2]:B RWOUT:B SPUI:B T1EN:B VDDA:B VNW:B VSB[1]:B VSB[2]:B
*.PININFO VSB[3]:B VSB[4]:B VSS:B WM[0]:B WM[1]:B WM[2]:B ZRR:B ag_ctrl:B
.ENDS

.SUBCKT xdec_strap BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBL1 EN ENB GRST LCLKB LXA[0] LXA[1] LXA[2] LXA[3] LXB[0] LXB[1]
+ LXB[2] LXB[3] LXC[0] LXC[1] LXC[2] LXC[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3]
+ PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+ QT[13] RM[0] RM[1] RM[2] RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3]
+ VSB[4] VSS WM[0] WM[1] WM[2] ZRR ag_ctrl
*.PININFO BPUI:B CSH_ENB:B CSH_LD:B CSH_RR:B CSH_YS[0]:B CSH_YS[1]:B
*.PININFO CSH_YS[2]:B CSH_YS[3]:B DBL1:B EN:B ENB:B GRST:B LCLKB:B LXA[0]:B
*.PININFO LXA[1]:B LXA[2]:B LXA[3]:B LXB[0]:B LXB[1]:B LXB[2]:B LXB[3]:B
*.PININFO LXC[0]:B LXC[1]:B LXC[2]:B LXC[3]:B LXWB[0]:B LXWB[1]:B LXWB[2]:B
*.PININFO LXWB[3]:B PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B
*.PININFO QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B RM[0]:B RM[1]:B
*.PININFO RM[2]:B RWOUT:B SPUI:B T1EN:B VDDA:B VNW:B VSB[1]:B VSB[2]:B
*.PININFO VSB[3]:B VSB[4]:B VSS:B WM[0]:B WM[1]:B WM[2]:B ZRR:B ag_ctrl:B
.ENDS

.SUBCKT floorplan_xdec_array
*.PININFO
XI66 net0577 net0201 net0808 net0563 net0554[0] net0554[1] net0554[2]
+ net0554[3] net0156 net0562 net0561 net0660 net0567 net0556[0] net0556[1]
+ net0556[2] net0556[3] net0571[0] net0571[1] net0571[2] net0571[3] net0568[0]
+ net0568[1] net0568[2] net0568[3] net0565[0] net0565[1] net0565[2] net0565[3]
+ net0566 net0558[0] net0558[1] net0558[2] net0558[3] net0558[4] net0558[5]
+ net0558[6] net0558[7] net0558[8] net0558[9] net0558[10] net0558[11]
+ net0560[0] net0560[1] net0560[2] net0555 net0575 net0559 net0576 net0827
+ net0573[0] net0573[1] net0573[2] net0573[3] net0570 net0569[0] net0569[1]
+ net0569[2] net0574 net0760 / xdec_edge
XI67 net0840 net028 net0598 net0596[0] net0596[1] net0596[2] net0596[3]
+ net0579 net02 net0599 net0601 net0595 net04[0] net04[1] net04[2] net04[3]
+ net0710 net0771[0] net0771[1] net0771[2] net0771[3] net0771[4] net0771[5]
+ net0771[6] net0771[7] net0771[8] net0771[9] net0771[10] net0771[11]
+ net0803[0] net0803[1] net0803[2] net03 net01 net0584 net0762 net0744 net0586
+ net0594 net0580 net0684 net0628[0] net0628[1] net0628[2] net0591 /
+ local_tmr_bitcell1
XI64 net0810 net0193 net0741 net0711 net0793[0] net0793[1] net0793[2]
+ net0793[3] net0709 net0787 net0498 net0486 net0790[0] net0790[1] net0790[2]
+ net0790[3] net0491[0] net0491[1] net0491[2] net0491[3] net0828[0] net0828[1]
+ net0828[2] net0828[3] net0835[0] net0835[1] net0835[2] net0835[3] net0775
+ net0477[0] net0477[1] net0477[2] net0477[3] net0477[4] net0477[5] net0477[6]
+ net0477[7] net0477[8] net0477[9] net0477[10] net0477[11] net0833[0]
+ net0833[1] net0833[2] net0645 net0745 net0749 net0675 net0637 net0789[0]
+ net0789[1] net0789[2] net0789[3] net0817 net0651[0] net0651[1] net0651[2]
+ net0651[3] net0815[0] net0815[1] net0815[2] net0697 net0630 / xdecrr
XI65 net0794 net077 net0814 net0508 net0499[0] net0499[1] net0499[2]
+ net0499[3] net0756 net0507 net0736 net0528 net0841 net0501[0] net0501[1]
+ net0501[2] net0501[3] net0629[0] net0629[1] net0629[2] net0629[3] net0515[0]
+ net0515[1] net0515[2] net0515[3] net0773[0] net0773[1] net0773[2] net0773[3]
+ net0513 net0768[0] net0768[1] net0768[2] net0768[3] net0768[4] net0768[5]
+ net0768[6] net0768[7] net0768[8] net0768[9] net0768[10] net0768[11]
+ net0665[0] net0665[1] net0665[2] net0500 net0831 net0504 net0526 net0520
+ net0521[0] net0521[1] net0521[2] net0521[3] net0723 net0634[0] net0634[1]
+ net0634[2] net0634[3] net0516[0] net0516[1] net0516[2] net0843 net0512
+ net0518 net0522 net0509 / xdec
XI68 net0707 net0108 net0633 net0726 net0837[0] net0837[1] net0837[2]
+ net0837[3] net024 net0825 net0659 net0447 net0823 net0425[0] net0425[1]
+ net0425[2] net0425[3] net0661[0] net0661[1] net0661[2] net0661[3] net0685[0]
+ net0685[1] net0685[2] net0685[3] net0434[0] net0434[1] net0434[2] net0434[3]
+ net0689 net0758[0] net0758[1] net0758[2] net0758[3] net0758[4] net0758[5]
+ net0758[6] net0758[7] net0758[8] net0758[9] net0758[10] net0758[11]
+ net0751[0] net0751[1] net0751[2] net0795 net0444 net0708 net0445 net0824
+ net0442[0] net0442[1] net0442[2] net0442[3] net0439 net0782[0] net0782[1]
+ net0782[2] net0690 net0692 / xdec_feedthru
XI63 net0842 net0135 net0451 net0800 net0448[0] net0448[1] net0448[2]
+ net0448[3] net050 net0721 net0676 net0679 net0461 net0706[0] net0706[1]
+ net0706[2] net0706[3] net0465[0] net0465[1] net0465[2] net0465[3] net0783[0]
+ net0783[1] net0783[2] net0783[3] net0829[0] net0829[1] net0829[2] net0829[3]
+ net0681 net0832[0] net0832[1] net0832[2] net0832[3] net0832[4] net0832[5]
+ net0832[6] net0832[7] net0832[8] net0832[9] net0832[10] net0832[11]
+ net0812[0] net0812[1] net0812[2] net0449 net0632 net0816 net0830 net0811
+ net0730[0] net0730[1] net0730[2] net0730[3] net0464 net0722[0] net0722[1]
+ net0722[2] net0776 net0836 / xdec_feedthru
XI55 net0552 net0162 net0754 net0538 net0529[0] net0529[1] net0529[2]
+ net0529[3] net0130 net0734 net0536 net0618 net0542 net0531[0] net0531[1]
+ net0531[2] net0531[3] net0797[0] net0797[1] net0797[2] net0797[3] net0821[0]
+ net0821[1] net0821[2] net0821[3] net0540[0] net0540[1] net0540[2] net0540[3]
+ net0807 net0533[0] net0533[1] net0533[2] net0533[3] net0533[4] net0533[5]
+ net0533[6] net0533[7] net0533[8] net0533[9] net0533[10] net0533[11]
+ net0668[0] net0668[1] net0668[2] net0796 net0834 net0769 net0788 net0547
+ net0548[0] net0548[1] net0548[2] net0548[3] net0545 net0544[0] net0544[1]
+ net0544[2] net0785 net0766 / xdec_strap
.ENDS

.SUBCKT nchpd B D G S
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_srpdlnfet m=1 l=l w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT nchpg B D G S
*.PININFO B:B D:B G:B S:B
MN0 D G S bulk! d_srpglnfet m=1 l=l w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT pchpu B D G S
*.PININFO B:B D:B G:B S:B
MP1 D G S bulk! d_srpulpfet m=1 l=l w=w nf=nf par=1 gcon=1 optNum=0
+ diffL=119.00n diffM=150.0n diffR=119.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=7.5e-08/w
+ nrd=7.5e-08/w
.ENDS

.SUBCKT bitcell_dummy_ld BLT DEVICE_BLT SETDBLB VDDA VNW VSS VSSX WL
*.PININFO BLT:B DEVICE_BLT:B SETDBLB:B VDDA:B VNW:B VSS:B VSSX:B WL:B
XM6 VSS net23 VSS VSSX / nchpd nf=1 w=196n l=58n
XM5 VSS net23 WL DEVICE_BLT / nchpg nf=1 w=96n l=60n
XPPUC net011 VSSX VSS net23 / pchpu nf=1 w=76n l=58n
.ENDS

.SUBCKT bitcell_edge_tmr DBL DEVBLT_BOT DEVBLT_TOP PWR SETDBLB VDDA VNW VSS
+ VSSX WL[0] WL[1] WL[2] WL[3]
*.PININFO DBL:B DEVBLT_BOT:B DEVBLT_TOP:B PWR:B SETDBLB:B VDDA:B VNW:B VSS:B
*.PININFO VSSX:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
XI46 net9 DBL SETDBLB VDDA VNW VSS VSSX WL[1] / bitcell_dummy_ld
XI42 net9 DBL SETDBLB VDDA VNW VSS VSSX WL[0] / bitcell_dummy_ld
XI40 net13 DBL SETDBLB VDDA VNW VSS VSSX WL[2] / bitcell_dummy_ld
XI47 net13 DBL SETDBLB VDDA VNW VSS VSSX WL[3] / bitcell_dummy_ld
.ENDS

.SUBCKT bitcell_edge_buf PWR VDDA VNW VSS
*.PININFO PWR:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT bitcell_edge_cm16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8]
+ BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3]
+ BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+ BT[15] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR
+ VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.PININFO BB[15]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B
*.PININFO BT[7]:B BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.PININFO BT[15]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.PININFO GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.PININFO GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B PWR:B
*.PININFO VDDA:B VNW:B VSS:B VSSX:B
XI44 BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] net018 net019 GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI76 BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] net020 net021 GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI79 BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15] net015 net016
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI45 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW GD GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
.ENDS

.SUBCKT bitcell_edge_cm8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BT[0]
+ BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] GBW GD GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.PININFO GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B VDDA:B VNW:B VSS:B VSSX:B
XI45 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW GD GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI44 BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] net22 net21 GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
.ENDS

.SUBCKT bitcell_edge_tmr_cap DBL PWR SETDBLB VDDA VNW VSS VSSX
*.PININFO DBL:B PWR:B SETDBLB:B VDDA:B VNW:B VSS:B VSSX:B
XM5 VSS net011 VSSX DBL / nchpg nf=1 w=96n l=60n
XPPUC net012 VSSX VSS net011 / pchpu nf=1 w=76n l=58n
XM6 VSS net011 VSS VSSX / nchpd nf=1 w=196n l=58n
.ENDS

.SUBCKT bitcell_base BLC BLT VDDA VNW VSS VSSX WL
*.PININFO BLC:B BLT:B VDDA:B VNW:B VSS:B VSSX:B WL:B
XNPT VSS BLT WL net12 / nchpg nf=1 w=96n l=60n
XNPC VSS BLC WL net13 / nchpg nf=1 w=96n l=60n
XNPDT VSS net12 net13 VSSX / nchpd nf=1 w=196n l=58n
XNPDC VSS net13 net12 VSSX / nchpd nf=1 w=196n l=58n
XPPUC VNW VDDA net12 net13 / pchpu nf=1 w=76n l=58n
XPPUT VNW VDDA net13 net12 / pchpu nf=1 w=76n l=58n
.ENDS

.SUBCKT bitcell_cm16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8]
+ BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3]
+ BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+ BT[15] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR
+ VDDA VNW VSS VSSX WL[0] WL[1] WL[2] WL[3]
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.PININFO BB[15]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B
*.PININFO BT[7]:B BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.PININFO BT[15]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.PININFO GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.PININFO GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B PWR:B
*.PININFO VDDA:B VNW:B VSS:B VSSX:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
XI40 BB[0] BT[0] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI68 BB[7] BT[7] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI67 BB[7] BT[7] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI66 BB[7] BT[7] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI65 BB[7] BT[7] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI64 BB[6] BT[6] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI63 BB[6] BT[6] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI62 BB[6] BT[6] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI61 BB[6] BT[6] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI60 BB[5] BT[5] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI59 BB[5] BT[5] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI58 BB[5] BT[5] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI57 BB[5] BT[5] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI56 BB[4] BT[4] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI55 BB[4] BT[4] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI54 BB[4] BT[4] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI53 BB[4] BT[4] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI52 BB[3] BT[3] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI51 BB[3] BT[3] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI50 BB[3] BT[3] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI49 BB[3] BT[3] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI48 BB[2] BT[2] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI47 BB[2] BT[2] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI46 BB[2] BT[2] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI45 BB[2] BT[2] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI44 BB[1] BT[1] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI43 BB[1] BT[1] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI42 BB[1] BT[1] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI41 BB[1] BT[1] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI16 BB[8] BT[8] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI39 BB[0] BT[0] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI38 BB[0] BT[0] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI37 BB[0] BT[0] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI31 BB[14] BT[14] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI30 BB[15] BT[15] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI29 BB[13] BT[13] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI28 BB[12] BT[12] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI27 BB[10] BT[10] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI26 BB[11] BT[11] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI25 BB[9] BT[9] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI24 BB[8] BT[8] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI23 BB[14] BT[14] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI22 BB[15] BT[15] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI21 BB[13] BT[13] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI20 BB[12] BT[12] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI19 BB[10] BT[10] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI18 BB[11] BT[11] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI17 BB[9] BT[9] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI15 BB[14] BT[14] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI14 BB[15] BT[15] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI13 BB[13] BT[13] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI12 BB[12] BT[12] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI11 BB[10] BT[10] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI10 BB[11] BT[11] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI9 BB[9] BT[9] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI8 BB[8] BT[8] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI7 BB[14] BT[14] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI6 BB[15] BT[15] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI5 BB[13] BT[13] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI4 BB[12] BT[12] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI3 BB[10] BT[10] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI2 BB[11] BT[11] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI1 BB[9] BT[9] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI0 BB[8] BT[8] VDDA VNW VSS VSSX WL[0] / bitcell_base
.ENDS

.SUBCKT bitcell_edge_only PWR VDDA VNW VSS VSSX
*.PININFO PWR:B VDDA:B VNW:B VSS:B VSSX:B
XM5 VSS VSSX VSSX VSSX / nchpg nf=1 w=96n l=60n
XM6 VSS VSSX net9 VSSX / nchpd nf=1 w=196n l=58n
XPPUC net011 VSSX net9 VSSX / pchpu nf=1 w=76n l=58n
.ENDS

.SUBCKT bitcell_cm4 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX WL[0] WL[1] WL[2] WL[3]
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B PWR:B VDDA:B
*.PININFO VNW:B VSS:B VSSX:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
XI7 BB[2] BT[2] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI4 BB[0] BT[0] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI5 BB[1] BT[1] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI6 BB[3] BT[3] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI13 BB[1] BT[1] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI12 BB[0] BT[0] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI15 BB[2] BT[2] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI14 BB[3] BT[3] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI21 BB[1] BT[1] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI20 BB[0] BT[0] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI23 BB[2] BT[2] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI22 BB[3] BT[3] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI29 BB[1] BT[1] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI28 BB[0] BT[0] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI31 BB[2] BT[2] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI30 BB[3] BT[3] VDDA VNW VSS VSSX WL[3] / bitcell_base
.ENDS

.SUBCKT bitcell_strap_buf PWR VDDA VNW VSS
*.PININFO PWR:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT bitcell_edge_coltmr_edge DBL PWR  VDDA VNW VSS VSSX
*.PININFO DBL:B PWR:B  VDDA:B VNW:B VSS:B VSSX:B
XM5 VSS net011 VSSX DBL / nchpg nf=1 w=96n l=60n
XPPUC net012 VSSX VSS net011 / pchpu nf=1 w=76n l=58n
XM6 VSS net011 VSS VSSX / nchpd nf=1 w=196n l=58n
.ENDS

.SUBCKT bitcell_cap_buf PWR VDDA VNW VSS
*.PININFO PWR:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT wl_rebuf_rdast EN ENB VSS WLR
*.PININFO EN:I ENB:I VSS:B WLR:B
XI35 VSS net27 ENB VSS / nch_lvtx nf=1 w=300n m=1
XI36 VSS WLR net27 VSS / nch_lvtx nf=1 w=600n m=1
XI37 VSS net27 EN WLR / nch_svtx nf=1 w=300n m=1
.ENDS

.SUBCKT wl_rebuf PWR VDDA VNW VSS WL[0] WL[1] WL[2] WL[3] WLI[0] WLI[1] WLI[2]
+ WLI[3]
*.PININFO PWR:B VDDA:B VNW:B VSS:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WLI[0]:B
*.PININFO WLI[1]:B WLI[2]:B WLI[3]:B
Xrdast[0] PWR VSS VSS WL[0] / wl_rebuf_rdast
Xrdast[1] PWR VSS VSS WL[1] / wl_rebuf_rdast
Xrdast[2] PWR VSS VSS WL[2] / wl_rebuf_rdast
Xrdast[3] PWR VSS VSS WL[3] / wl_rebuf_rdast
XI13[0] VSS VSS WLI[0] net028[0] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI13[1] VSS VSS WLI[1] net028[1] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI13[2] VSS VSS WLI[2] net028[2] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI13[3] VSS VSS WLI[3] net028[3] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI14[0] VSS VSS net028[0] WL[0] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14[1] VSS VSS net028[1] WL[1] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14[2] VSS VSS net028[2] WL[2] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14[3] VSS VSS net028[3] WL[3] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
.ENDS

.SUBCKT bitcell_cap_cm16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8]
+ BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3]
+ BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+ BT[15] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR
+ VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.PININFO BB[15]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B
*.PININFO BT[7]:B BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.PININFO BT[15]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.PININFO GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.PININFO GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B PWR:B
*.PININFO VDDA:B VNW:B VSS:B VSSX:B
XI44 BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] net018 net019 GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI76 BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] net020 net021 GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI79 BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15] net015 net016
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI45 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW GD GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
.ENDS

.SUBCKT bitcell_cm8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BT[0]
+ BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] GBW GD GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX WL[0] WL[1]
+ WL[2] WL[3]
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.PININFO GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B VDDA:B VNW:B VSS:B VSSX:B
*.PININFO WL[0]:B WL[1]:B WL[2]:B WL[3]:B
XI31 BB[6] BT[6] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI30 BB[7] BT[7] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI29 BB[5] BT[5] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI28 BB[4] BT[4] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI27 BB[2] BT[2] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI26 BB[3] BT[3] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI25 BB[1] BT[1] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI24 BB[0] BT[0] VDDA VNW VSS VSSX WL[3] / bitcell_base
XI23 BB[6] BT[6] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI22 BB[7] BT[7] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI21 BB[5] BT[5] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI20 BB[4] BT[4] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI19 BB[2] BT[2] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI18 BB[3] BT[3] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI17 BB[1] BT[1] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI16 BB[0] BT[0] VDDA VNW VSS VSSX WL[2] / bitcell_base
XI15 BB[6] BT[6] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI14 BB[7] BT[7] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI13 BB[5] BT[5] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI12 BB[4] BT[4] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI11 BB[2] BT[2] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI10 BB[3] BT[3] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI9 BB[1] BT[1] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI8 BB[0] BT[0] VDDA VNW VSS VSSX WL[1] / bitcell_base
XI7 BB[6] BT[6] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI6 BB[7] BT[7] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI5 BB[5] BT[5] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI4 BB[4] BT[4] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI3 BB[2] BT[2] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI2 BB[3] BT[3] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI1 BB[1] BT[1] VDDA VNW VSS VSSX WL[0] / bitcell_base
XI0 BB[0] BT[0] VDDA VNW VSS VSSX WL[0] / bitcell_base
.ENDS

.SUBCKT bitcell_base_ech BLC BLT VDDA VNW VSS VSSX
*.PININFO BLC:B BLT:B VDDA:B VNW:B VSS:B VSSX:B
XNPT VSS BLT VSSX net12 / nchpg nf=1 w=96n l=60n
XNPC VSS BLC VSSX net13 / nchpg nf=1 w=96n l=60n
XNPDT VSS net12 net13 VSSX / nchpd nf=1 w=196n l=58n
XNPDC VSS net13 net12 VSSX / nchpd nf=1 w=196n l=58n
XPPUC VNW VDDA net12 net13 / pchpu nf=1 w=76n l=58n
XPPUT VNW VDDA net13 net12 / pchpu nf=1 w=76n l=58n
.ENDS

.SUBCKT bitcell_edge_cm4 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW
+ GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B PWR:B VDDA:B
*.PININFO VNW:B VSS:B VSSX:B
XI49 BB[3] BT[3] VDDA VNW VSS VSSX / bitcell_base_ech
XI48 BB[2] BT[2] VDDA VNW VSS VSSX / bitcell_base_ech
XI46 BB[0] BT[0] VDDA VNW VSS VSSX / bitcell_base_ech
XI47 BB[1] BT[1] VDDA VNW VSS VSSX / bitcell_base_ech
.ENDS

.SUBCKT bitcell_edge_coltmr_wl DBL PWR RWL VDDA VNW VSS VSSX PD[0] PD[1] PD[2] PD[3]
*.PININFO DBL:B PWR:B RWL:B VDDA:B VNW:B VSS:B VSSX:B
XI51 net025 DBL net06 VDDA VNW VSS VSSX VSSX / bitcell_dummy_ld
XI49 net022 DBL net06 VDDA VNW VSS VSSX VSS / bitcell_dummy_ld
XI40 net022 DBL net06 VDDA VNW VSS VSSX RWL / bitcell_dummy_ld
XI42 net017 DBL net06 VDDA VNW VSS VSSX VSS / bitcell_dummy_ld
XI50 net017 DBL net06 VDDA VNW VSS VSSX VDDA / bitcell_dummy_ld
.ENDS

.SUBCKT bitcell_base_cut BLC BLC_TOP BLT BLT_TOP VDDA VNW VSS VSSX WL
*.PININFO BLC:B BLC_TOP:B BLT:B BLT_TOP:B VDDA:B VNW:B VSS:B VSSX:B WL:B
XNPT VSS BLT_TOP WL net12 / nchpg nf=1 w=96n l=60n
XNPC VSS BLC WL net13 / nchpg nf=1 w=96n l=60n
XNPDT VSS net12 net13 VSSX / nchpd nf=1 w=196n l=58n
XNPDC VSS net13 net12 VSSX / nchpd nf=1 w=196n l=58n
XPPUC VNW VDDA net12 net13 / pchpu nf=1 w=76n l=58n
XPPUT VNW VDDA net13 net12 / pchpu nf=1 w=76n l=58n
.ENDS

.SUBCKT local_tmr_wl_cm4 BB[0] BB[1] BB[2] BB[3] BB_TOP[0] BB_TOP[1] BB_TOP[2]
+ BB_TOP[3] BT[0] BT[1] BT[2] BT[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR
+ RWL VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B
*.PININFO BB_TOP[3]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B GBW:B GD:B GRD0[0]:B
*.PININFO GRD0[1]:B GRD0[2]:B GRD0[3]:B PWR:B RWL:B VDDA:B VNW:B VSS:B VSSX:B
XI6 BB[3] BB_TOP[3] BT[3] VDDA VDDA VNW VSS VSSX VSS / bitcell_base_cut
XI7 BB[2] BB_TOP[2] BT[2] VDDA VDDA VNW VSS VSSX VSS / bitcell_base_cut
XI5 BB[1] BB_TOP[1] BT[1] VDDA VDDA VNW VSS VSSX VSS / bitcell_base_cut
XI4 BB[0] BB_TOP[0] BT[0] VDDA VDDA VNW VSS VSSX VSS / bitcell_base_cut
XI14 BB_TOP[3] VDDA VDDA VNW VSS VSSX VDDA / bitcell_base
XI22 BB_TOP[3] VDDA VDDA VNW VSS VSSX RWL / bitcell_base
XI30 BB_TOP[3] VDDA VDDA VNW VSS VSSX VSS / bitcell_base
XI15 BB_TOP[2] VDDA VDDA VNW VSS VSSX VDDA / bitcell_base
XI23 BB_TOP[2] VDDA VDDA VNW VSS VSSX RWL / bitcell_base
XI31 BB_TOP[2] VDDA VDDA VNW VSS VSSX VSS / bitcell_base
XI13 BB_TOP[1] VDDA VDDA VNW VSS VSSX VDDA / bitcell_base
XI21 BB_TOP[1] VDDA VDDA VNW VSS VSSX RWL / bitcell_base
XI29 BB_TOP[1] VDDA VDDA VNW VSS VSSX VSS / bitcell_base
XI12 BB_TOP[0] VDDA VDDA VNW VSS VSSX VDDA / bitcell_base
XI20 BB_TOP[0] VDDA VDDA VNW VSS VSSX RWL / bitcell_base
XI28 BB_TOP[0] VDDA VDDA VNW VSS VSSX VSS / bitcell_base
XI46 BB_TOP[0] VDDA VDDA VNW VSS VSSX / bitcell_base_ech
XI47 BB_TOP[1] VDDA VDDA VNW VSS VSSX / bitcell_base_ech
XI48 BB_TOP[2] VDDA VDDA VNW VSS VSSX / bitcell_base_ech
XI49 BB_TOP[3] VDDA VDDA VNW VSS VSSX / bitcell_base_ech
.ENDS

.SUBCKT local_tmr_wl_cm16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+ BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB_TOP[0] BB_TOP[1]
+ BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8]
+ BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11]
+ BT[12] BT[13] BT[14] BT[15] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] PWR RWL VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.PININFO BB[15]:B BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B
*.PININFO BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BB_TOP[8]:B BB_TOP[9]:B
*.PININFO BB_TOP[10]:B BB_TOP[11]:B BB_TOP[12]:B BB_TOP[13]:B BB_TOP[14]:B
*.PININFO BB_TOP[15]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B
*.PININFO BT[7]:B BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.PININFO BT[15]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.PININFO GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.PININFO GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B PWR:B
*.PININFO RWL:B VDDA:B VNW:B VSS:B VSSX:B
XI44 BB[12] BB[13] BB[14] BB[15] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ BT[12] BT[13] BT[14] BT[15] net24 net25 net22[0] net22[1] net22[2] net22[3]
+ PWR RWL VDDA VNW VSS VSSX / local_tmr_wl_cm4
XI45 BB[8] BB[9] BB[10] BB[11] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BT[8]
+ BT[9] BT[10] BT[11] net19 net20 net17[0] net17[1] net17[2] net17[3] PWR RWL
+ VDDA VNW VSS VSSX / local_tmr_wl_cm4
XI47 BB[4] BB[5] BB[6] BB[7] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BT[4]
+ BT[5] BT[6] BT[7] net9 net10 net7[0] net7[1] net7[2] net7[3] PWR RWL VDDA
+ VNW VSS VSSX / local_tmr_wl_cm4
XI46 BB[0] BB[1] BB[2] BB[3] BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BT[0]
+ BT[1] BT[2] BT[3] net14 net15 net12[0] net12[1] net12[2] net12[3] PWR RWL
+ VDDA VNW VSS VSSX / local_tmr_wl_cm4
.ENDS

.SUBCKT local_tmr_wl_buf PWR VDDA VNW VSS
*.PININFO PWR:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT bitcell_strap_cm16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+ BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2]
+ BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+ BT[15] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR
+ VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.PININFO BB[15]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B
*.PININFO BT[7]:B BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.PININFO BT[15]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.PININFO GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.PININFO GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B PWR:B
*.PININFO VDDA:B VNW:B VSS:B VSSX:B
.ENDS

.SUBCKT bitcell_edge_tmr_strap DBL DEVBLT_BOT DEVBLT_TOP PWR SETDBLB VDDA VNW
+ VSS VSSX
*.PININFO DBL:B DEVBLT_BOT:B DEVBLT_TOP:B PWR:B SETDBLB:B VDDA:B VNW:B VSS:B
*.PININFO VSSX:B
.ENDS

.SUBCKT bitcell_dummy_edge BLT DEVICE_BLT SETDBLB VDDA VNW VSS VSSX WL
*.PININFO BLT:B DEVICE_BLT:B SETDBLB:B VDDA:B VNW:B VSS:B VSSX:B WL:B
XM6 VSS DEVICE_BLT net06 VSSX / nchpd nf=1 w=196n l=58n
XPPUC net09 VSSX net06 DEVICE_BLT / pchpu nf=1 w=76n l=58n
XM5 VSS DEVICE_BLT WL DEVICE_BLT / nchpg nf=1 w=96n l=60n
.ENDS

.SUBCKT bitcell_edge_tmr_wl PWR RWL VDDA VNW VSS VSSX
*.PININFO PWR:B RWL:B VDDA:B VNW:B VSS:B VSSX:B
XI49 net022 VSSX net020 VDDA VNW VSS VSSX VSS / bitcell_dummy_edge
XI50 net021 VSSX net020 VDDA VNW VSS VSSX VDDA / bitcell_dummy_edge
XI51 net023 VSSX net020 VDDA VNW VSS VSSX VSSX / bitcell_dummy_edge
XI42 net021 VSSX net020 VDDA VNW VSS VSSX VSS / bitcell_dummy_edge
XI40 net022 VSSX net020 VDDA VNW VSS VSSX RWL / bitcell_dummy_edge
.ENDS

.SUBCKT bitcell_edge PWR VDDA VNW VSS VSSX WL[0] WL[1] WL[2] WL[3]
*.PININFO PWR:B VDDA:B VNW:B VSS:B VSSX:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
XI47 net020 VSSX net06 VDDA VNW VSS VSSX WL[3] / bitcell_dummy_edge
XI40 net020 VSSX net06 VDDA VNW VSS VSSX WL[2] / bitcell_dummy_edge
XI42 net016 VSSX net06 VDDA VNW VSS VSSX WL[0] / bitcell_dummy_edge
XI53 net016 VSSX net06 VDDA VNW VSS VSSX WL[1] / bitcell_dummy_edge
.ENDS

.SUBCKT bitcell_edge_strap PWR VDDA VNW VSS VSSX
*.PININFO PWR:B VDDA:B VNW:B VSS:B VSSX:B
.ENDS

.SUBCKT bitcell_edge_cap PWR VDDA VNW VSS VSSX
*.PININFO PWR:B VDDA:B VNW:B VSS:B VSSX:B
XM5 VSS VSSX VSSX VSSX / nchpg nf=1 w=96n l=60n
XM6 VSS VSSX net9 VSSX / nchpd nf=1 w=196n l=58n
XPPUC net011 VSSX net9 VSSX / pchpu nf=1 w=76n l=58n
.ENDS

.SUBCKT bitcell_cap_cm8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BT[0]
+ BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] GBW GD GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.PININFO GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B VDDA:B VNW:B VSS:B VSSX:B
XI45 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW GD GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
XI44 BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] net22 net21 GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX / bitcell_cap_cm4
.ENDS

.SUBCKT bitcell_strap_cm8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+ BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] GBW GD GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.PININFO GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B VDDA:B VNW:B VSS:B VSSX:B
.ENDS

.SUBCKT local_tmr_wl_cm8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+ BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6]
+ BB_TOP[7] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] GBW GD GRD0[0]
+ GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] PWR RWL VDDA VNW VSS
+ VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.PININFO BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B
*.PININFO BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B
*.PININFO BT[4]:B BT[5]:B BT[6]:B BT[7]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B
*.PININFO RWL:B VDDA:B VNW:B VSS:B VSSX:B
XI47 BB[4] BB[5] BB[6] BB[7] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BT[4]
+ BT[5] BT[6] BT[7] net9 net10 net7[0] net7[1] net7[2] net7[3] PWR RWL VDDA
+ VNW VSS VSSX / local_tmr_wl_cm4
XI46 BB[0] BB[1] BB[2] BB[3] BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BT[0]
+ BT[1] BT[2] BT[3] net14 net15 net12[0] net12[1] net12[2] net12[3] PWR RWL
+ VDDA VNW VSS VSSX / local_tmr_wl_cm4
.ENDS

.SUBCKT bitcell_cap_cm4 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B PWR:B VDDA:B
*.PININFO VNW:B VSS:B VSSX:B
XI49 BB[3] BT[3] VDDA VNW VSS VSSX / bitcell_base_ech
XI48 BB[2] BT[2] VDDA VNW VSS VSSX / bitcell_base_ech
XI46 BB[0] BT[0] VDDA VNW VSS VSSX / bitcell_base_ech
XI47 BB[1] BT[1] VDDA VNW VSS VSSX / bitcell_base_ech
.ENDS

.SUBCKT bitcell_strap_cm4 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] GBW
+ GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] PWR VDDA VNW VSS VSSX
*.PININFO BB[0]:B BB[1]:B BB[2]:B BB[3]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B PWR:B VDDA:B
*.PININFO VNW:B VSS:B VSSX:B
.ENDS

.SUBCKT floorplan_bc_array
*.PININFO
XI53 net0541 net0519 net0524 net0546 net0549 net0551 net0543 net0511 net0553
+ net0505[0] net0505[1] net0505[2] net0505[3] / bitcell_edge_tmr
XI51 net0527 net0392 net04 net0534 net0510 net0523 net0503 net0530 net0532
+ net0539[0] net0539[1] net0539[2] net0539[3] / bitcell_edge_tmr
XI68 net0215 net0647 net0624 net0642 / bitcell_edge_buf
XI74 net0733[0] net0733[1] net0733[2] net0733[3] net0733[4] net0733[5]
+ net0733[6] net0733[7] net0733[8] net0733[9] net0733[10] net0733[11]
+ net0733[12] net0733[13] net0733[14] net0733[15] net0730[0] net0730[1]
+ net0730[2] net0730[3] net0730[4] net0730[5] net0730[6] net0730[7] net0730[8]
+ net0730[9] net0730[10] net0730[11] net0730[12] net0730[13] net0730[14]
+ net0730[15] net0721 net0571 net0589[0] net0589[1] net0589[2] net0589[3]
+ net0725[0] net0725[1] net0725[2] net0725[3] net0731[0] net0731[1] net0731[2]
+ net0731[3] net0663[0] net0663[1] net0663[2] net0663[3] net0669 net0632
+ net0712 net0741 net0726 / bitcell_edge_cm16
XI71 net0563[0] net0563[1] net0563[2] net0563[3] net0563[4] net0563[5]
+ net0563[6] net0563[7] net0563[8] net0563[9] net0563[10] net0563[11]
+ net0563[12] net0563[13] net0563[14] net0563[15] net0683[0] net0683[1]
+ net0683[2] net0683[3] net0683[4] net0683[5] net0683[6] net0683[7] net0683[8]
+ net0683[9] net0683[10] net0683[11] net0683[12] net0683[13] net0683[14]
+ net0683[15] net0671 net0535 net0554[0] net0554[1] net0554[2] net0554[3]
+ net0676[0] net0676[1] net0676[2] net0676[3] net0682[0] net0682[1] net0682[2]
+ net0682[3] net028[0] net028[1] net028[2] net028[3] net0572 net0591 net030
+ net0691 net0677 / bitcell_edge_cm16
XI73 net0724[0] net0724[1] net0724[2] net0724[3] net0724[4] net0724[5]
+ net0724[6] net0724[7] net0550[0] net0550[1] net0550[2] net0550[3] net0550[4]
+ net0550[5] net0550[6] net0550[7] net0661 net057 net0734[0] net0734[1]
+ net0734[2] net0734[3] net0745[0] net0745[1] net0745[2] net0745[3] net0630
+ net0738 net0743 net0728 net0604 / bitcell_edge_cm8
XI70 net0680[0] net0680[1] net0680[2] net0680[3] net0680[4] net0680[5]
+ net0680[6] net0680[7] net0646[0] net0646[1] net0646[2] net0646[3] net0646[4]
+ net0646[5] net0646[6] net0646[7] net043 net044 net0660[0] net0660[1]
+ net0660[2] net0660[3] net0692[0] net0692[1] net0692[2] net0692[3] net045
+ net046 net0633 net047 net048 / bitcell_edge_cm8
XI56 net0335 net0339 net0342 net0341 net0337 net0343 net0344 /
+ bitcell_edge_tmr_cap
XI47 net0460[0] net0460[1] net0460[2] net0460[3] net0460[4] net0460[5]
+ net0460[6] net0460[7] net0460[8] net0460[9] net0460[10] net0460[11]
+ net0460[12] net0460[13] net0460[14] net0460[15] net0433[0] net0433[1]
+ net0433[2] net0433[3] net0433[4] net0433[5] net0433[6] net0433[7] net0433[8]
+ net0433[9] net0433[10] net0433[11] net0433[12] net0433[13] net0433[14]
+ net0433[15] net0120 net0121 net0483[0] net0483[1] net0483[2] net0483[3]
+ net0383[0] net0383[1] net0383[2] net0383[3] net0489[0] net0489[1] net0489[2]
+ net0489[3] net0431[0] net0431[1] net0431[2] net0431[3] net0122 net0124
+ net0390 net0495 net0432 net0427[0] net0427[1] net0427[2] net0427[3] /
+ bitcell_cm16
XI28 net0245[0] net0245[1] net0245[2] net0245[3] net0245[4] net0245[5]
+ net0245[6] net0245[7] net0245[8] net0245[9] net0245[10] net0245[11]
+ net0245[12] net0245[13] net0245[14] net0245[15] net0221[0] net0221[1]
+ net0221[2] net0221[3] net0221[4] net0221[5] net0221[6] net0221[7] net0221[8]
+ net0221[9] net0221[10] net0221[11] net0221[12] net0221[13] net0221[14]
+ net0221[15] net0246 net071 net0208[0] net0208[1] net0208[2] net0208[3]
+ net0220[0] net0220[1] net0220[2] net0220[3] net0241[0] net0241[1] net0241[2]
+ net0241[3] net0233[0] net0233[1] net0233[2] net0233[3] net072 net074 net0249
+ net0234 net0210 net073[0] net073[1] net073[2] net073[3] / bitcell_cm16
XI66 net0561 net0638 net0596 net0628 net0606 / bitcell_edge_only
XI62 net0621 net0506 net0608 net0437 net0438 / bitcell_edge_only
XI50 net0425[0] net0425[1] net0425[2] net0425[3] net0403[0] net0403[1]
+ net0403[2] net0403[3] net0197 net0198 net0434[0] net0434[1] net0434[2]
+ net0434[3] net0199 net0201 net0398 net0202 net0203 net0200[0] net0200[1]
+ net0200[2] net0200[3] / bitcell_cm4
XI39 net0205[0] net0205[1] net0205[2] net0205[3] net0206[0] net0206[1]
+ net0206[2] net0206[3] net0367 net0209 net0204[0] net0204[1] net0204[2]
+ net0204[3] net0470 net0481 net0207 net0213 net0466 net0211[0] net0211[1]
+ net0211[2] net0211[3] / bitcell_cm4
XI11 net0142[0] net0142[1] net0142[2] net0142[3] net060[0] net060[1] net060[2]
+ net060[3] net48 net50 net0143[0] net0143[1] net0143[2] net0143[3] net49
+ net46 net51 net47 net062 net0135[0] net0135[1] net0135[2] net0135[3] /
+ bitcell_cm4
XI5 net036[0] net036[1] net036[2] net036[3] net037[0] net037[1] net037[2]
+ net037[3] net038 net039 net035[0] net035[1] net035[2] net035[3] net106
+ net102 net103 net104 net041 net040[0] net040[1] net040[2] net040[3] /
+ bitcell_cm4
XI34 net018 net016 net017 net015 / bitcell_strap_buf
XI58 net0166 net0583 net0395 net0610 net0502 net0581 / bitcell_edge_coltmr_edge
XI32 net0302 net0327 net0264 net0331 / bitcell_cap_buf
XI67 net0552 net0573 net0547 net0607 net0620[0] net0620[1] net0620[2]
+ net0620[3] net0112[0] net0112[1] net0112[2] net0112[3] / wl_rebuf
XI33 net061 net058 net063 net059 net076[0] net076[1] net076[2] net076[3]
+ net075[0] net075[1] net075[2] net075[3] / wl_rebuf
XI0 net6 net3 net5 net2 net070[0] net070[1] net070[2] net070[3] net069[0]
+ net069[1] net069[2] net069[3] / wl_rebuf
XI46 net0454[0] net0454[1] net0454[2] net0454[3] net0454[4] net0454[5]
+ net0454[6] net0454[7] net0454[8] net0454[9] net0454[10] net0454[11]
+ net0454[12] net0454[13] net0454[14] net0454[15] net0487[0] net0487[1]
+ net0487[2] net0487[3] net0487[4] net0487[5] net0487[6] net0487[7] net0487[8]
+ net0487[9] net0487[10] net0487[11] net0487[12] net0487[13] net0487[14]
+ net0487[15] net0467 net0374 net0485[0] net0485[1] net0485[2] net0485[3]
+ net0455[0] net0455[1] net0455[2] net0455[3] net0468[0] net0468[1] net0468[2]
+ net0468[3] net0369[0] net0369[1] net0369[2] net0369[3] net0379 net0376
+ net0459 net0456 net0450 / bitcell_cap_cm16
XI27 net049[0] net049[1] net049[2] net049[3] net049[4] net049[5] net049[6]
+ net049[7] net049[8] net049[9] net049[10] net049[11] net049[12] net049[13]
+ net049[14] net049[15] net053[0] net053[1] net053[2] net053[3] net053[4]
+ net053[5] net053[6] net053[7] net053[8] net053[9] net053[10] net053[11]
+ net053[12] net053[13] net053[14] net053[15] net056 net0212 net050[0]
+ net050[1] net050[2] net050[3] net051[0] net051[1] net051[2] net051[3]
+ net055[0] net055[1] net055[2] net055[3] net052[0] net052[1] net052[2]
+ net052[3] net0238 net0247 net054 net0224 net0227 / bitcell_cap_cm16
XI43 net0323[0] net0323[1] net0323[2] net0323[3] net0323[4] net0323[5]
+ net0323[6] net0323[7] net0324[0] net0324[1] net0324[2] net0324[3] net0324[4]
+ net0324[5] net0324[6] net0324[7] net0326 net0391 net0322[0] net0322[1]
+ net0322[2] net0322[3] net0321[0] net0321[1] net0321[2] net0321[3] net0328
+ net0330 net0325 net0417 net0332 net0329[0] net0329[1] net0329[2] net0329[3]
+ / bitcell_cm8
XI25 net0187[0] net0187[1] net0187[2] net0187[3] net0187[4] net0187[5]
+ net0187[6] net0187[7] net0188[0] net0188[1] net0188[2] net0188[3] net0188[4]
+ net0188[5] net0188[6] net0188[7] net0190 net0191 net0186[0] net0186[1]
+ net0186[2] net0186[3] net0185[0] net0185[1] net0185[2] net0185[3] net0192
+ net0194 net0189 net0195 net0196 net0193[0] net0193[1] net0193[2] net0193[3]
+ / bitcell_cm8
XI72 net0687[0] net0687[1] net0687[2] net0687[3] net0688[0] net0688[1]
+ net0688[2] net0688[3] net0665 net0710 net0673[0] net0673[1] net0673[2]
+ net0673[3] net0686 net0595 net0701 net0700 net0697 / bitcell_edge_cm4
XI69 net0181[0] net0181[1] net0181[2] net0181[3] net0182[0] net0182[1]
+ net0182[2] net0182[3] net0184 net0636 net0625[0] net0625[1] net0625[2]
+ net0625[3] net0634 net0569 net0183 net0643 net0652 / bitcell_edge_cm4
XI77 net0263 net0265 net0747 net0266 net0708 net0755 net0765 PD[0] PD[1] PD[2] PD[3] /
+ bitcell_edge_coltmr_wl
XI49 net0494[0] net0494[1] net0494[2] net0494[3] net0494[4] net0494[5]
+ net0494[6] net0494[7] net0494[8] net0494[9] net0494[10] net0494[11]
+ net0494[12] net0494[13] net0494[14] net0494[15] net0658[0] net0658[1]
+ net0658[2] net0658[3] net0658[4] net0658[5] net0658[6] net0658[7] net0658[8]
+ net0658[9] net0658[10] net0658[11] net0658[12] net0658[13] net0658[14]
+ net0658[15] net0493[0] net0493[1] net0493[2] net0493[3] net0493[4]
+ net0493[5] net0493[6] net0493[7] net0493[8] net0493[9] net0493[10]
+ net0493[11] net0493[12] net0493[13] net0493[14] net0493[15] net0421 net0488
+ net0484[0] net0484[1] net0484[2] net0484[3] net0472[0] net0472[1] net0472[2]
+ net0472[3] net0440[0] net0440[1] net0440[2] net0440[3] net0389[0] net0389[1]
+ net0389[2] net0389[3] net0430 net0789 net0414 net0441 net0457 net0401 /
+ local_tmr_wl_cm16
XI30 net0222[0] net0222[1] net0222[2] net0222[3] net0222[4] net0222[5]
+ net0222[6] net0222[7] net0222[8] net0222[9] net0222[10] net0222[11]
+ net0222[12] net0222[13] net0222[14] net0222[15] net0287[0] net0287[1]
+ net0287[2] net0287[3] net0287[4] net0287[5] net0287[6] net0287[7] net0287[8]
+ net0287[9] net0287[10] net0287[11] net0287[12] net0287[13] net0287[14]
+ net0287[15] net033[0] net033[1] net033[2] net033[3] net033[4] net033[5]
+ net033[6] net033[7] net033[8] net033[9] net033[10] net033[11] net033[12]
+ net033[13] net033[14] net033[15] net0240 net0216 net0231[0] net0231[1]
+ net0231[2] net0231[3] net031[0] net031[1] net031[2] net031[3] net0239[0]
+ net0239[1] net0239[2] net0239[3] net032[0] net032[1] net032[2] net032[3]
+ net0244 net0286 net0225 net034 net0229 net042 / local_tmr_wl_cm16
XI35 net06 net03 net05 net02 / local_tmr_wl_buf
XI48 net0453[0] net0453[1] net0453[2] net0453[3] net0453[4] net0453[5]
+ net0453[6] net0453[7] net0453[8] net0453[9] net0453[10] net0453[11]
+ net0453[12] net0453[13] net0453[14] net0453[15] net0479[0] net0479[1]
+ net0479[2] net0479[3] net0479[4] net0479[5] net0479[6] net0479[7] net0479[8]
+ net0479[9] net0479[10] net0479[11] net0479[12] net0479[13] net0479[14]
+ net0479[15] net0462 net0394 net0393[0] net0393[1] net0393[2] net0393[3]
+ net0375[0] net0375[1] net0375[2] net0375[3] net0471[0] net0471[1] net0471[2]
+ net0471[3] net0473[0] net0473[1] net0473[2] net0473[3] net0380 net0397
+ net0490 net0497 net0409 / bitcell_strap_cm16
XI29 net077[0] net077[1] net077[2] net077[3] net077[4] net077[5] net077[6]
+ net077[7] net077[8] net077[9] net077[10] net077[11] net077[12] net077[13]
+ net077[14] net077[15] net081[0] net081[1] net081[2] net081[3] net081[4]
+ net081[5] net081[6] net081[7] net081[8] net081[9] net081[10] net081[11]
+ net081[12] net081[13] net081[14] net081[15] net084 net085 net078[0]
+ net078[1] net078[2] net078[3] net079[0] net079[1] net079[2] net079[3]
+ net083[0] net083[1] net083[2] net083[3] net080[0] net080[1] net080[2]
+ net080[3] net086 net088 net082 net089 net090 / bitcell_strap_cm16
XI57 net099 net0514 net0517 net0103 net0106 net0105 net0597 net0614 net0619 /
+ bitcell_edge_tmr_strap
XI76 net0644 net0756 net0336 net0334 net0760 net0338 / bitcell_edge_tmr_wl
XI75 net0340 net0556 net0627 net0526 net0761 net0753 / bitcell_edge_tmr_wl
XI64 net0637 net0501 net0531 net0566 net0399 net0629[0] net0629[1] net0629[2]
+ net0629[3] / bitcell_edge
XI54 net0310 net0308 net0309 net0306 net0587 net0307[0] net0307[1] net0307[2]
+ net0307[3] / bitcell_edge
XI31 net012 net010 net011 net09 net0631 net064[0] net064[1] net064[2]
+ net064[3] / bitcell_edge
XI60 net0413 net0612 net0411 net0443 net0590 net0537[0] net0537[1] net0537[2]
+ net0537[3] / bitcell_edge
XI65 net0575 net0640 net0601 net0576 net0422 / bitcell_edge_strap
XI61 net0616 net0452 net0525 net0557 net0428 / bitcell_edge_strap
XI63 net0385 net0386 net0384 net0542 net0388 / bitcell_edge_cap
XI59 net0615 net0405 net0617 net0407 net0408 / bitcell_edge_cap
XI42 net0171[0] net0171[1] net0171[2] net0171[3] net0171[4] net0171[5]
+ net0171[6] net0171[7] net0172[0] net0172[1] net0172[2] net0172[3] net0172[4]
+ net0172[5] net0172[6] net0172[7] net0174 net0175 net0170[0] net0170[1]
+ net0170[2] net0170[3] net0169[0] net0169[1] net0169[2] net0169[3] net0176
+ net0178 net0173 net0179 net0180 / bitcell_cap_cm8
XI20 net093[0] net093[1] net093[2] net093[3] net093[4] net093[5] net093[6]
+ net093[7] net094[0] net094[1] net094[2] net094[3] net094[4] net094[5]
+ net094[6] net094[7] net096 net097 net092[0] net092[1] net092[2] net092[3]
+ net091[0] net091[1] net091[2] net091[3] net098 net0100 net095 net0101
+ net0102 / bitcell_cap_cm8
XI44 net0377[0] net0377[1] net0377[2] net0377[3] net0377[4] net0377[5]
+ net0377[6] net0377[7] net0480[0] net0480[1] net0480[2] net0480[3] net0480[4]
+ net0480[5] net0480[6] net0480[7] net0463 net0446 net0410[0] net0410[1]
+ net0410[2] net0410[3] net0419[0] net0419[1] net0419[2] net0419[3] net0250
+ net0252 net0420 net0253 net0254 / bitcell_strap_cm8
XI21 net0133[0] net0133[1] net0133[2] net0133[3] net0133[4] net0133[5]
+ net0133[6] net0133[7] net0134[0] net0134[1] net0134[2] net0134[3] net0134[4]
+ net0134[5] net0134[6] net0134[7] net0136 net0137 net0132[0] net0132[1]
+ net0132[2] net0132[3] net0131[0] net0131[1] net0131[2] net0131[3] net0230
+ net0140 net0237 net0235 net0243 / bitcell_strap_cm8
XI45 net0269[0] net0269[1] net0269[2] net0269[3] net0269[4] net0269[5]
+ net0269[6] net0269[7] net0780[0] net0780[1] net0780[2] net0780[3] net0780[4]
+ net0780[5] net0780[6] net0780[7] net0270[0] net0270[1] net0270[2] net0270[3]
+ net0270[4] net0270[5] net0270[6] net0270[7] net0272 net0273 net0268[0]
+ net0268[1] net0268[2] net0268[3] net0267[0] net0267[1] net0267[2] net0267[3]
+ net0274 net0751 net0276 net0271 net0277 net0278 / local_tmr_wl_cm8
XI26 net0145[0] net0145[1] net0145[2] net0145[3] net0145[4] net0145[5]
+ net0145[6] net0145[7] net0771[0] net0771[1] net0771[2] net0771[3] net0771[4]
+ net0771[5] net0771[6] net0771[7] net0146[0] net0146[1] net0146[2] net0146[3]
+ net0146[4] net0146[5] net0146[6] net0146[7] net0148 net0149 net0214[0]
+ net0214[1] net0214[2] net0214[3] net0218[0] net0218[1] net0218[2] net0218[3]
+ net0150 net0776 net0152 net0147 net0153 net0154 / local_tmr_wl_cm8
XI38 net0346[0] net0346[1] net0346[2] net0346[3] net0347[0] net0347[1]
+ net0347[2] net0347[3] net0349 net0350 net0345[0] net0345[1] net0345[2]
+ net0345[3] net0351 net0353 net0348 net0354 net0355 / bitcell_cap_cm4
XI12 net0114[0] net0114[1] net0114[2] net0114[3] net0115[0] net0115[1]
+ net0115[2] net0115[3] net0116 net0117 net0113[0] net0113[1] net0113[2]
+ net0113[3] net143 net140 net145 net141 net0119 / bitcell_cap_cm4
XI40 net0387[0] net0387[1] net0387[2] net0387[3] net0478[0] net0478[1]
+ net0478[2] net0478[3] net0400 net0415 net0476[0] net0476[1] net0476[2]
+ net0476[3] net0423 net0474 net0469 net0492 net0458 / bitcell_strap_cm4
XI10 net026[0] net026[1] net026[2] net026[3] net027[0] net027[1] net027[2]
+ net027[3] net113 net115 net025[0] net025[1] net025[2] net025[3] net114
+ net109 net110 net112 net029 / bitcell_strap_cm4
XI41 net08[0] net08[1] net08[2] net08[3] net0507[0] net0507[1] net0507[2]
+ net0507[3] net0475[0] net0475[1] net0475[2] net0475[3] net0429 net0424
+ net07[0] net07[1] net07[2] net07[3] net013 net0693 net0435 net0482 net0418
+ net0496 / local_tmr_wl_cm4
XI9 net0138[0] net0138[1] net0138[2] net0138[3] net0558[0] net0558[1]
+ net0558[2] net0558[3] net0125[0] net0125[1] net0125[2] net0125[3] net96
+ net98 net91[0] net91[1] net91[2] net91[3] net97 net0518 net93 net94 net95
+ net0144 / local_tmr_wl_cm4
.ENDS

.SUBCKT floorplan_sbank
*.PININFO
XI59  / floorplan_xdec_array
XI11  / floorplan_bc_array
XI10  / floorplan_bc_array
.ENDS

.SUBCKT nand2_svt A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XP0 Pb P A Y / pch_svt nf=1 w=p_w m=pm
XP1 Pb P B Y / pch_svt nf=1 w=p_w m=pm
XN0 Gb Y A net10 / nch_svt nf=1 w=n_w m=nm
XN1 Gb net10 B G / nch_svt nf=1 w=n_w m=nm
.ENDS

.SUBCKT giopg BPU PWR VDDA VNW VSS
*.PININFO BPU:B PWR:B VDDA:B VNW:B VSS:B
XI207 VNW PWR BPU VDDA / pch nf=1 w=600n m=16
.ENDS

.SUBCKT nor2_svt A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XP1 Pb P B net12 / pch_svt nf=1 w=p_w m=pm
XP0 Pb net12 A Y / pch_svt nf=1 w=p_w m=pm
XN0 Gb Y A G / nch_svt nf=1 w=n_w m=nm
XN1 Gb Y B G / nch_svt nf=1 w=n_w m=nm
.ENDS

.SUBCKT globlatr A CB CT PWR QB QT RS VDDP VSS
*.PININFO A:I CB:I CT:I RS:I QB:O QT:O PWR:B VDDP:B VSS:B
XI24 VDDP PWR net022 z1 / pch nf=1 w=360n m=1
XI16 VDDP PWR QT net032 / pch nf=1 w=240n m=1
XI17 VDDP net032 CT z1 / pch nf=1 w=240n m=1
XI21 A CT CB net031 net024 PWR VDDP z1 / tri_svt nm=1 n_w=240n pm=1 p_w=360n
XI22 RS z1 VSS VSS PWR VDDP QT / nor2_svt nm=1 n_w=240n pm=1 p_w=360n
XI15 VSS VSS QT QB PWR VDDP / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI25 VSS VSS RS net022 PWR VDDP / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI23 net024 net031 net022 VSS / nch nf=1 w=240n m=1
XI18 VSS z1 CB net023 / nch nf=1 w=240n m=1
XI19 VSS net023 QT VSS / nch nf=1 w=240n m=1
.ENDS

.SUBCKT dffr A CB CT PWR QB QT RS VDDP VSS
*.PININFO A:I CB:I CT:I RS:I QB:O QT:O PWR:B VDDP:B VSS:B
XXL1 net15 CT CB PWR QB QT RS VDDP VSS / globlatr
XXL0 A CB CT PWR net16 net15 RS VDDP VSS / globlatr
.ENDS

.SUBCKT gctlpg A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11]
+ A[12] A[13] AWT BISTE BPU BPUI CACHE_EN CACHE_MISS CE CLK HN PWR RA RM[0]
+ RM[1] RM[2] RRMATCH SD SL SPU SPUI SZ TA[0] TA[1] TA[2] TA[3] TA[4] TA[5]
+ TA[6] TA[7] TA[8] TA[9] TA[10] TA[11] TA[12] TA[13] TCACHE_EN TCE TCLK TEST1
+ TRRMATCH TWE VDDA VNW VSB100 VSB200 VSB300 VSB400 VSS WE WM[0] WM[1] WM[2]
*.PININFO A[0]:B A[1]:B A[2]:B A[3]:B A[4]:B A[5]:B A[6]:B A[7]:B A[8]:B
*.PININFO A[9]:B A[10]:B A[11]:B A[12]:B A[13]:B AWT:B BISTE:B BPU:B BPUI:B
*.PININFO CACHE_EN:B CACHE_MISS:B CE:B CLK:B HN:B PWR:B RA:B RM[0]:B RM[1]:B
*.PININFO RM[2]:B RRMATCH:B SD:B SL:B SPU:B SPUI:B SZ:B TA[0]:B TA[1]:B
*.PININFO TA[2]:B TA[3]:B TA[4]:B TA[5]:B TA[6]:B TA[7]:B TA[8]:B TA[9]:B
*.PININFO TA[10]:B TA[11]:B TA[12]:B TA[13]:B TCACHE_EN:B TCE:B TCLK:B TEST1:B
*.PININFO TRRMATCH:B TWE:B VDDA:B VNW:B VSB100:B VSB200:B VSB300:B VSB400:B
*.PININFO VSS:B WE:B WM[0]:B WM[1]:B WM[2]:B
XI41 HN SD SL VSS VSS VDDA VNW net08 / nor3 pm=1 p_w=960n nm=1 n_w=240n
XD2 SZ VSS / ant_diode nf=1 w=240nm m=1
XI527 net020 net028 VSS VSS VDDA VNW net017 / nand2_svt nm=1 n_w=480n pm=1
+ p_w=480n
XI523 net08 net017 VSS VSS VDDA VNW net012 / nand2_svt nm=1 n_w=480n pm=1
+ p_w=480n
XI499 en y[15] VSS VSS VDDA VNW enb / nand2_svt nm=1 n_w=480n pm=1 p_w=480n
XI535 VSS VSS SPUI net032 VDDA VNW / inv_svt nm=1 n_w=480n pm=1 p_w=720n
XI517 VSS VSS net012 en VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
XI528 VSS VSS net017 BPUI VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
XI520 VSS VSS net08 SPUI VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
XI532 VSS VSS BPUI BPU VDDA VNW / inv_svt nm=4 n_w=480n pm=4 p_w=720n
XI498[0] VSS VSS enb y[0] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[1] VSS VSS y[0] y[1] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[2] VSS VSS y[1] y[2] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[3] VSS VSS y[2] y[3] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[4] VSS VSS y[3] y[4] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[5] VSS VSS y[4] y[5] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[6] VSS VSS y[5] y[6] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[7] VSS VSS y[6] y[7] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[8] VSS VSS y[7] y[8] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[9] VSS VSS y[8] y[9] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[10] VSS VSS y[9] y[10] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[11] VSS VSS y[10] y[11] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[12] VSS VSS y[11] y[12] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[13] VSS VSS y[12] y[13] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[14] VSS VSS y[13] y[14] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI498[15] VSS VSS y[14] y[15] VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI534 VSS VSS net032 SPU VDDA VNW / inv_svt nm=4 n_w=480n pm=4 p_w=720n
XI516 VSS VSS net08 RST VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
XI529[0] BPU PWR VDDA VNW VSS / giopg
XI529[1] BPU PWR VDDA VNW VSS / giopg
XI529[2] BPU PWR VDDA VNW VSS / giopg
XI529[3] BPU PWR VDDA VNW VSS / giopg
XI529[4] BPU PWR VDDA VNW VSS / giopg
XI529[5] BPU PWR VDDA VNW VSS / giopg
XI529[6] BPU PWR VDDA VNW VSS / giopg
XI529[7] BPU PWR VDDA VNW VSS / giopg
XI526 zqb[1] zqb[2] VSS VSS VDDA VNW net028 / nor2_svt nm=1 n_w=240n pm=1
+ p_w=720n
XI524 zqb[4] zqb[3] VSS VSS VDDA VNW net020 / nor2_svt nm=1 n_w=240n pm=1
+ p_w=720n
XXD[0] zqb[0] y[0] y[1] VDDA zqb[0] zqt[0] RST VNW VSS / dffr
XXD[1] zqb[1] zqb[0] zqt[0] VDDA zqb[1] zqt[1] RST VNW VSS / dffr
XXD[2] zqb[2] zqb[1] zqt[1] VDDA zqb[2] zqt[2] RST VNW VSS / dffr
XXD[3] zqb[3] zqb[2] zqt[2] VDDA zqb[3] zqt[3] RST VNW VSS / dffr
XXD[4] zqb[4] zqb[3] zqt[3] VDDA zqb[4] zqt[4] RST VNW VSS / dffr
XXD[5] zqb[5] zqb[4] zqt[4] VDDA zqb[5] zqt[5] RST VNW VSS / dffr
XXD[6] zqb[6] zqb[5] zqt[5] VDDA zqb[6] zqt[6] RST VNW VSS / dffr
XXD[7] zqb[7] zqb[6] zqt[6] VDDA zqb[7] zqt[7] RST VNW VSS / dffr
XI531 VSS PWR RST VSS / nch nf=1 w=240n m=4
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
.ENDS

.SUBCKT gctl_cache_cm4 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10]
+ A[11] A[12] A[13] AWT BISTE BK[0] BK[1] BPUI BS[0] BS[1] BS[2] BS[3] BWBR
+ CACHE_EN CACHE_MISS CE CLK CS[0] CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR
+ CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBR EN ENB GRST HN LCLKIO PREOUT PWR
+ QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+ RA RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT
+ SZ T1EN TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10]
+ TA[11] TA[12] TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW
+ VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1]
+ WM[2] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I A[8]:I
*.PININFO A[9]:I A[10]:I A[11]:I A[12]:I A[13]:I CE:I CLK:I GRST:I RA:I
*.PININFO RM[0]:I RM[1]:I RM[2]:I TA[0]:I TA[1]:I TA[2]:I TA[3]:I TA[4]:I
*.PININFO TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I TA[11]:I TA[12]:I
*.PININFO TA[13]:I TCE:I TCLK:I TEST1:I TWE:I WE:I WM[0]:I WM[1]:I WM[2]:I
*.PININFO BS[0]:O BS[1]:O BS[2]:O BS[3]:O CACHE_MISS:O CS[0]:O CS[1]:O CS[2]:O
*.PININFO CS[3]:O CSH_ENB:O CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O
*.PININFO CSH_YS[2]:O CSH_YS[3]:O EN:O ENB:O LCLKIO:O QT[2]:O QT[3]:O QT[4]:O
*.PININFO QT[5]:O QT[6]:O QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O
*.PININFO QT[13]:O RMO[0]:O RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O
*.PININFO WMO[2]:O ZRR:O AWT:B BISTE:B BK[0]:B BK[1]:B BPUI:B BWBR:B
*.PININFO CACHE_EN:B DBR:B HN:B PREOUT:B PWR:B RPIN:B RRMATCH:B SD:B SL:B
*.PININFO SPUI:B SWT:B SZ:B TCACHE_EN:B TE:B TRRMATCH:B VDDA:B VNW:B VSB100:B
*.PININFO VSB200:B VSB300:B VSB400:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B
*.PININFO ag_ctrl:B
XI481 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] A[12]
+ A[13] AWT BISTE net059 net058 BPUI BWBR CACHE_EN CACHE_MISS CE CLK CS[0]
+ CS[1] CS[2] CS[3] CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBR EN ENB GRST HN LCLKIO net060 PREOUT PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RA RM[0] RM[1]
+ RM[2] RMO[0] RMO[1] RMO[2] RPIN RRMATCH RWOUT SD SL SPUI SWT SZ T1EN TA[0]
+ TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10] TA[11] TA[12]
+ TA[13] TCACHE_EN TCE TCLK TE TEST1 TRRMATCH TWE VDDA VNW VSB100 VSB200
+ VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1] WM[2] WMO[0]
+ WMO[1] WMO[2] ZRR ag_ctrl / gctl_cache_base
.ENDS

.SUBCKT gctl_grdmx BPUI CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ EN ENB GRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+ QT[11] QT[12] QT[13] RMO[0] RMO[1] RMO[2] RWOUT SPUI T1EN VSB[1] VSB[2]
+ VSB[3] VSB[4] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl
*.PININFO GRST:I CSH_LD:O CSH_RR:O CSH_YS[0]:O CSH_YS[1]:O CSH_YS[2]:O
*.PININFO CSH_YS[3]:O EN:O ENB:O QT[2]:O QT[3]:O QT[4]:O QT[5]:O QT[6]:O
*.PININFO QT[7]:O QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O QT[13]:O RMO[0]:O
*.PININFO RMO[1]:O RMO[2]:O RWOUT:O T1EN:O WMO[0]:O WMO[1]:O WMO[2]:O ZRR:O
*.PININFO BPUI:B PWR:B SPUI:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B ag_ctrl:B
.ENDS

.SUBCKT giopg1 BADIO BPU BWM D PWR Q SPU TBWM TD VDDA VNW VSS
*.PININFO BADIO:B BPU:B BWM:B D:B PWR:B Q:B SPU:B TBWM:B TD:B VDDA:B VNW:B
*.PININFO VSS:B
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
XI201 VSS Q SPU VSS / nch nf=1 w=480n m=1
XI200 BPU PWR VDDA VNW VSS / giopg
.ENDS

.SUBCKT giopg_rebuf BPU BPUI PWR SPU SPUI VDDA VNW VSS
*.PININFO BPU:B BPUI:B PWR:B SPU:B SPUI:B VDDA:B VNW:B VSS:B
XI20 VSS VSS BPUI net032 VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
XI19 VSS VSS net032 BPU VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI25 VSS VSS net035 SPU VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI26 VSS VSS SPUI net035 VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
.ENDS

.SUBCKT giopg4 BADIO BPU BWM D PWR Q SPU TBWM TD VDDA VNW VSS
*.PININFO BADIO:B BPU:B BWM:B D:B PWR:B Q:B SPU:B TBWM:B TD:B VDDA:B VNW:B
*.PININFO VSS:B
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
XI201 VSS Q SPU VSS / nch nf=1 w=480n m=1
XI200[0] BPU PWR VDDA VNW VSS / giopg
XI200[1] BPU PWR VDDA VNW VSS / giopg
XI200[2] BPU PWR VDDA VNW VSS / giopg
XI200[3] BPU PWR VDDA VNW VSS / giopg
.ENDS

.SUBCKT gpg_edge BPU PWR SPU VDDA VNW VSS
*.PININFO BPU:B PWR:B SPU:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT giopg2 BADIO BPU BWM D PWR Q SPU TBWM TD VDDA VNW VSS
*.PININFO BADIO:B BPU:B BWM:B D:B PWR:B Q:B SPU:B TBWM:B TD:B VDDA:B VNW:B
*.PININFO VSS:B
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
XI201 VSS Q SPU VSS / nch nf=1 w=480n m=1
XI200[0] BPU PWR VDDA VNW VSS / giopg
XI200[1] BPU PWR VDDA VNW VSS / giopg
.ENDS

.SUBCKT floorplan_gpg
*.PININFO
XI39 net0139 net0155 net0168 net0165 net0166 net0158 net0141 net0162 net0176
+ net0145 net0163 net0156 / giopg1
XI12 net139 net01 net124 net125 net143 net126 net02 net134 net133 net140
+ net145 net141 / giopg1
XI5 net0105 net014 net0360 net0368 net106 net0367 net015 net0100 net099 net102
+ net103 net104 / giopg1
XI38 net08 net04 net0117 net0115 net0116 net03 net05 net07 net06 net0102
+ net013 net0109 / giopg1
XI44 net056 net058 net0178 net0204 net0207 net057 net0216 net055 / giopg_rebuf
XI32 net029 net030 net0302 net028 net027 net0327 net0264 net0331 / giopg_rebuf
XI0 net053 net054 net6 net052 net051 net3 net5 net2 / giopg_rebuf
XI30 net0196 net059 net0181 net0182 net0200 net0183 net060 net0191 net0190
+ net0197 net0202 net0198 / giopg4
XI41 net092 net088 net085 net086 net096 net087 net089 net091 net090 net093
+ net097 net094 / giopg4
XI43 net0107 net0192 net0108 net0186 net0210 net0110 / gpg_edge
XI42 net0174 net0212 net0209 net0161 net0205 net0208 / gpg_edge
XI31 net037 net012 net036 net010 net011 net09 / gpg_edge
XI3 net045 net12 net044 net10 net11 net9 / gpg_edge
XI40 net0169 net0114 net0111 net0112 net0122 net0113 net0167 net0177 net0173
+ net0119 net0123 net0120 / giopg2
XI26 net0148 net072 net0133 net0134 net0152 net0135 net073 net0143 net0142
+ net0149 net0154 net0150 / giopg2
.ENDS

.SUBCKT aoi21_lvt A B C G Gb P Pb Y
*.PININFO A:I B:I C:I Y:O G:B Gb:B P:B Pb:B
XI15 Gb Y A G / nch_lvt nf=1 w=n_w m=nm
XN0 Gb Y B net10 / nch_lvt nf=1 w=n_w m=nm
XN1 Gb net10 C G / nch_lvt nf=1 w=n_w m=nm
XI14 Pb net011 A Y / pch_lvt nf=1 w=p_w m=pm
XP0 Pb P B net011 / pch_lvt nf=1 w=p_w m=pm
XP1 Pb P C net011 / pch_lvt nf=1 w=p_w m=pm
.ENDS

.SUBCKT sapx_lvt A B C PWR RB RDB SAET SAPR VDDA VNW VSS
*.PININFO A:I B:I C:I RB:I RDB:I SAET:O SAPR:O PWR:B VDDA:B VNW:B VSS:B
XI8 RB SAE1 VSS VSS PWR VNW net046 / nand2 pm=2 p_w=720n nm=2 n_w=960n
XI16 net40 net54 VSS VSS PWR VNW SAE1 / nand2 pm=2 p_w=720n nm=2 n_w=960n
XI17 RB SAE1 VSS VSS PWR VNW net54 / nand2 pm=1 p_w=720n nm=1 n_w=960n
XI10 VSS VSS net046 SAET PWR VNW / inv_lvt pm=4 p_w=1440n nm=4 n_w=960n
XI12 VSS VSS net56 SAPR PWR VNW / inv_lvt pm=4 p_w=1440n nm=4 n_w=960n
XI236 VSS VSS SAE1 net56 PWR VNW / inv_lvt pm=2 p_w=1440n nm=2 n_w=960n
XI195 VSS VSS net39 net40 PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI14 net51 RDB VSS VSS PWR VNW net39 / nor2_lvt nm=1 n_w=480n pm=1 p_w=960n
XI13 A B C VSS VSS PWR VNW net51 / aoi21_lvt pm=1 p_w=480n nm=1 n_w=480n
.ENDS

.SUBCKT half_lat2 A CB CT PWR QB VNW VSS
*.PININFO A:I CB:I CT:I QB:O PWR:B VNW:B VSS:B
XI11 CB CT VSS A DT VNW / txgate nm=1 n_w=240n pm=1 p_w=360n
XI18 VSS DT CT net023 / nch_lvtx nf=1 w=240n m=1
XI19 VSS net023 QB VSS / nch_lvtx nf=1 w=240n m=1
XI21 VSS VSS DT QB PWR VNW / inv_lvt pm=2 p_w=360n nm=2 n_w=240n
XI16 VNW PWR QB net032 / pch_lvtx nf=1 w=240n m=1
XI17 VNW net032 CB DT / pch_lvtx nf=1 w=240n m=1
.ENDS

.SUBCKT salx4_cache_lvt A[0] A[1] A[2] A[3] BKSEL CB CSH_EN CT PWR Q[0] Q[1]
+ Q[2] Q[3] VNW VSS
*.PININFO A[0]:I A[1]:I A[2]:I A[3]:I BKSEL:I CSH_EN:I Q[0]:O Q[1]:O Q[2]:O
*.PININFO Q[3]:O CB:B CT:B PWR:B VNW:B VSS:B
XI8[0] VSS VSS net024[0] net028[0] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI8[1] VSS VSS net024[1] net028[1] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI8[2] VSS VSS net024[2] net028[2] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI8[3] VSS VSS net024[3] net028[3] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI7[0] VSS VSS net028[0] net029[0] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI7[1] VSS VSS net028[1] net029[1] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI7[2] VSS VSS net028[2] net029[2] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI7[3] VSS VSS net028[3] net029[3] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI3[0] VSS VSS net016[0] Q[0] PWR VNW / inv_lvt pm=4 p_w=1440n nm=2 n_w=1920n
XI3[1] VSS VSS net016[1] Q[1] PWR VNW / inv_lvt pm=4 p_w=1440n nm=2 n_w=1920n
XI3[2] VSS VSS net016[2] Q[2] PWR VNW / inv_lvt pm=4 p_w=1440n nm=2 n_w=1920n
XI3[3] VSS VSS net016[3] Q[3] PWR VNW / inv_lvt pm=4 p_w=1440n nm=2 n_w=1920n
XI2[0] VSS VSS net029[0] net016[0] PWR VNW / inv_lvt pm=2 p_w=1440n nm=2
+ n_w=960n
XI2[1] VSS VSS net029[1] net016[1] PWR VNW / inv_lvt pm=2 p_w=1440n nm=2
+ n_w=960n
XI2[2] VSS VSS net029[2] net016[2] PWR VNW / inv_lvt pm=2 p_w=1440n nm=2
+ n_w=960n
XI2[3] VSS VSS net029[3] net016[3] PWR VNW / inv_lvt pm=2 p_w=1440n nm=2
+ n_w=960n
XI0[0] net013[0] CB CT PWR net024[0] VNW VSS / half_lat2
XI0[1] net013[1] CB CT PWR net024[1] VNW VSS / half_lat2
XI0[2] net013[2] CB CT PWR net024[2] VNW VSS / half_lat2
XI0[3] net013[3] CB CT PWR net024[3] VNW VSS / half_lat2
XI9 VSS net018 BKSEL VSS / nch_lvt nf=1 w=480n m=1
XI1[0] A[0] CSH_EN net018 VSS PWR VNW net013[0] / nor2_lvt nm=1 n_w=480n pm=1
+ p_w=960n
XI1[1] A[1] CSH_EN net018 VSS PWR VNW net013[1] / nor2_lvt nm=1 n_w=480n pm=1
+ p_w=960n
XI1[2] A[2] CSH_EN net018 VSS PWR VNW net013[2] / nor2_lvt nm=1 n_w=480n pm=1
+ p_w=960n
XI1[3] A[3] CSH_EN net018 VSS PWR VNW net013[3] / nor2_lvt nm=1 n_w=480n pm=1
+ p_w=960n
XI10[0] VNW PWR BKSEL net013[0] / pch_lvt nf=1 w=360n m=2
XI10[1] VNW PWR BKSEL net013[1] / pch_lvt nf=1 w=360n m=2
XI10[2] VNW PWR BKSEL net013[2] / pch_lvt nf=1 w=360n m=2
XI10[3] VNW PWR BKSEL net013[3] / pch_lvt nf=1 w=360n m=2
.ENDS

.SUBCKT ldecz2to4 A0 A1 PWR VNW VSS X[0] X[1] X[2] X[3]
*.PININFO A0:I A1:I X[0]:O X[1]:O X[2]:O X[3]:O PWR:B VNW:B VSS:B
XI18 VSS VSS A1 A1B PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI17 VSS VSS A0 A0B PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI16 A1B A0B VSS VSS PWR VNW X[0] / nand2 pm=1 p_w=720n nm=1 n_w=960n
XI15 A1B A0 VSS VSS PWR VNW X[1] / nand2 pm=1 p_w=720n nm=1 n_w=960n
XI14 A1 A0B VSS VSS PWR VNW X[2] / nand2 pm=1 p_w=720n nm=1 n_w=960n
XI13 A1 A0 VSS VSS PWR VNW X[3] / nand2 pm=1 p_w=720n nm=1 n_w=960n
.ENDS

.SUBCKT nand2_svtx A B G Gb P Pb Y
*.PININFO A:I B:I Y:O G:B Gb:B P:B Pb:B
XP0 Pb P A Y / pch_svtx nf=1 w=p_w m=pm
XP1 Pb P B Y / pch_svtx nf=1 w=p_w m=pm
XN0 Gb Y A net10 / nch_svtx nf=1 w=n_w m=nm
XN1 Gb net10 B G / nch_svtx nf=1 w=n_w m=nm
.ENDS

.SUBCKT ldec2to4 A0 A1 PWR VNW VSS X[0] X[1] X[2] X[3]
*.PININFO A0:I A1:I X[0]:O X[1]:O X[2]:O X[3]:O PWR:B VNW:B VSS:B
XI41 VSS VSS net32 X[3] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI10 VSS VSS net33 X[2] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI11 VSS VSS net31 X[0] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI12 VSS VSS net34 X[1] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI18 VSS VSS A1 A1B PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI17 VSS VSS A0 A0B PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI16 A1B A0B VSS VSS PWR VNW net31 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI15 A1B A0 VSS VSS PWR VNW net34 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI14 A1 A0B VSS VSS PWR VNW net33 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI13 A1 A0 VSS VSS PWR VNW net32 / nand2 pm=1 p_w=360n nm=1 n_w=480n
.ENDS

.SUBCKT ldec2to4_clk A0 A1 PWR VNW VSS X[0] X[1] X[2] X[3]
*.PININFO A0:I A1:I X[0]:O X[1]:O X[2]:O X[3]:O PWR:B VNW:B VSS:B
XI14 VSS VSS A0 A0B PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI18 VSS VSS A1 A1B PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI10 A1 A0 VSS VSS PWR VNW X[3] / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI11 A1 A0B VSS VSS PWR VNW X[2] / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI12 A1B A0 VSS VSS PWR VNW X[1] / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI13 A1B A0B VSS VSS PWR VNW X[0] / nand2 pm=1 p_w=360n nm=1 n_w=480n
.ENDS

.SUBCKT nand3_lvt A B C G Gb P Pb Y
*.PININFO A:I B:I C:I Y:O G:B Gb:B P:B Pb:B
XN0 Gb Y A net15 / nch_lvt nf=1 w=n_w m=nm
XN2 Gb net014 C G / nch_lvt nf=1 w=n_w m=nm
XN1 Gb net15 B net014 / nch_lvt nf=1 w=n_w m=nm
XP2 Pb P C Y / pch_lvt nf=1 w=p_w m=pm
XP1 Pb P B Y / pch_lvt nf=1 w=p_w m=pm
XP0 Pb P A Y / pch_lvt nf=1 w=p_w m=pm
.ENDS

.SUBCKT sactl BK0 BK1 BK2 BKSEL BPUI BSTB C1 CS[0] CS[1] CS[2] CS[3] CSH_ENB
+ CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBL1 EN ENB GRST LCLKB
+ LRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RM[0] RM[1] RM[2] RWOUT SAET SAPR SPUI T1EN TIMER_SEL VDDA VNW
+ VSB[1] VSB[2] VSB[3] VSB[4] VSS WLRST WM[0] WM[1] WM[2] WMH[0] WMH[1] WMH[2]
+ XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3]
+ XWB[0] XWB[1] XWB[2] XWB[3] XZB[0] XZB[1] XZB[2] XZB[3] YSEL[0] YSEL[1]
+ YSEL[2] YSEL[3] ZB0 ZB1 ZB2 ZB2_QT13 ZRR ag_ctrl
*.PININFO CSH_ENB:I CSH_LD:I CSH_RR:I DBL1:I T1EN:I TIMER_SEL:I WM[0]:I
*.PININFO WM[1]:I WM[2]:I ZB2_QT13:I BKSEL:O BSTB:O CS[0]:O CS[1]:O CS[2]:O
*.PININFO CS[3]:O GRST:O LCLKB:O SAET:O SAPR:O WMH[0]:O WMH[1]:O WMH[2]:O
*.PININFO XA[0]:O XA[1]:O XA[2]:O XA[3]:O XB[0]:O XB[1]:O XB[2]:O XB[3]:O
*.PININFO XC[0]:O XC[1]:O XC[2]:O XC[3]:O XWB[0]:O XWB[1]:O XWB[2]:O XWB[3]:O
*.PININFO YSEL[0]:O YSEL[1]:O YSEL[2]:O YSEL[3]:O BK0:B BK1:B BK2:B BPUI:B
*.PININFO C1:B CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B EN:B ENB:B
*.PININFO LRST:B PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B
*.PININFO QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B RM[0]:B RM[1]:B RM[2]:B
*.PININFO RWOUT:B SPUI:B VDDA:B VNW:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B
*.PININFO VSS:B WLRST:B XZB[0]:B XZB[1]:B XZB[2]:B XZB[3]:B ZB0:B ZB1:B ZB2:B
*.PININFO ZRR:B ag_ctrl:B
XISA CSH_RR CSH_LD BKSEL PWR LRST RWOUT SAET SAPR VDDA VNW VSS / sapx_lvt
XI267 LRST NOBST net044 VSS VSS PWR VNW net071 / nand3 pm=1 p_w=720n nm=1
+ n_w=1.44u
XI266 wmi[1] wmi[0] wmi[2] VSS VSS PWR VNW NOBST / nand3 pm=1 p_w=360n nm=1
+ n_w=720n
XI325 net085 net047 VSS VSS PWR VNW net084 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI251 BKSEL RWOUT VSS VSS PWR VNW net070 / nand2 pm=1 p_w=720n nm=1 n_w=960n
XI328 CSH_ENB RWOUT VSS VSS PWR VNW CSH_EN / nor2_lvtx pm=1 p_w=480n nm=1
+ n_w=240n
XI284 RWOUT net065 VSS VSS PWR VNW WLRST / nor2_lvtx pm=1 p_w=720n nm=1
+ n_w=240n
XI290 T1EN net073 VSS VSS PWR VNW net072 / nor2_lvtx pm=1 p_w=1.44u nm=1
+ n_w=480n
XICS CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] BKSEL net0105 CSH_EN LRST PWR
+ CS[0] CS[1] CS[2] CS[3] VNW VSS / salx4_cache_lvt
XI326 VSS VSS ZB2_QT13 net047 PWR VNW / inv_svtx nm=1 n_w=240n pm=1 p_w=360n
XI295[0] VSS VSS wmi[0] WMH[0] PWR VNW / inv_svtx nm=4 n_w=320n pm=4 p_w=640n
XI295[1] VSS VSS wmi[1] WMH[1] PWR VNW / inv_svtx nm=4 n_w=320n pm=4 p_w=640n
XI295[2] VSS VSS wmi[2] WMH[2] PWR VNW / inv_svtx nm=4 n_w=320n pm=4 p_w=640n
XI264[0] VSS VSS WM[0] wmi[0] PWR VNW / inv_svtx nm=2 n_w=320n pm=2 p_w=640n
XI264[1] VSS VSS WM[1] wmi[1] PWR VNW / inv_svtx nm=2 n_w=320n pm=2 p_w=640n
XI264[2] VSS VSS WM[2] wmi[2] PWR VNW / inv_svtx nm=2 n_w=320n pm=2 p_w=640n
XI324 VSS VSS net084 BKSEL PWR VNW / inv_svtx nm=1 n_w=480n pm=1 p_w=720n
XXZDEC BK0 BK1 PWR VNW VSS XZB[0] XZB[1] XZB[2] XZB[3] / ldecz2to4
XI291 VSS VSS net065 LRST PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=480n
XI249 VSS VSS net071 net083 PWR VNW / inv_lvt pm=2 p_w=1440n nm=2 n_w=960n
XI250 VSS VSS net070 net044 PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI318 VSS VSS ZRR net95 PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI123 VSS VSS net072 LCLKB VDDA VNW / inv_lvt pm=2 p_w=1.35u nm=2 n_w=0.9u
XI268 VSS VSS LRST net0105 PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI305 VSS VSS BK2 ZB2 PWR VNW / inv_lvt pm=8 p_w=720n nm=8 n_w=480n
XI248 VSS VSS net083 BSTB PWR VNW / inv_lvt pm=4 p_w=1440n nm=4 n_w=960n
XI274 VSS VSS LRST GRST VDDA VNW / inv_lvt pm=2 p_w=1.08u nm=2 n_w=0.72u
XI289 net072 net064 VSS VSS VDDA VNW net065 / nand2_svtx nm=1 n_w=480n pm=1
+ p_w=360n
XYDEC QT[2] QT[3] PWR VNW VSS YSEL[0] YSEL[1] YSEL[2] YSEL[3] / ldec2to4
XXADEC QT[6] QT[7] PWR VNW VSS XA[0] XA[1] XA[2] XA[3] / ldec2to4
XXBDEC QT[8] QT[9] PWR VNW VSS XB[0] XB[1] XB[2] XB[3] / ldec2to4
XXCDEC QT[10] C1 PWR VNW VSS XC[0] XC[1] XC[2] XC[3] / ldec2to4
XCKDEC QT[4] QT[5] PWR VNW VSS XWB[0] XWB[1] XWB[2] XWB[3] / ldec2to4_clk
XI304 VSS VSS DBL1 net064 PWR VNW / inv_svt nm=1 n_w=240n pm=1 p_w=360n
XI319 ZB0 ZB1 net95 VSS VSS PWR VNW net085 / nand3_lvt pm=1 p_w=360n nm=1
+ n_w=480n
XI13 CSH_RR CSH_LD TIMER_SEL VSS VSS VDDA VNW net073 / aoi21_lvt pm=1 p_w=480n
+ nm=1 n_w=480n
.ENDS

.SUBCKT nor3_lvt A B C G Gb P Pb Y
*.PININFO A:I B:I C:I Y:O G:B Gb:B P:B Pb:B
XN0 Gb Y A G / nch_lvt nf=1 w=n_w m=nm
XN2 Gb Y C G / nch_lvt nf=1 w=n_w m=nm
XN1 Gb Y B G / nch_lvt nf=1 w=n_w m=nm
XP2 Pb P C net19 / pch_lvt nf=1 w=p_w m=pm
XP0 Pb net019 A Y / pch_lvt nf=1 w=p_w m=pm
XP1 Pb net19 B net019 / pch_lvt nf=1 w=p_w m=pm
.ENDS

.SUBCKT aoi32_lvt A0 A1 B0 B1 B2 G Gb P Pb Y
*.PININFO A0:I A1:I B0:I B1:I B2:I Y:O G:B Gb:B P:B Pb:B
XI18 Gb net024 A1 G / nch_lvt nf=1 w=n_w m=nm
XN2 Gb net025 B2 G / nch_lvt nf=1 w=n_w m=nm
XI15 Gb Y A0 net024 / nch_lvt nf=1 w=n_w m=nm
XN0 Gb Y B0 net10 / nch_lvt nf=1 w=n_w m=nm
XN1 Gb net10 B1 net025 / nch_lvt nf=1 w=n_w m=nm
XI19 Pb net011 A1 Y / pch_lvt nf=1 w=p_w m=pm
XI17 Pb P B2 net011 / pch_lvt nf=1 w=p_w m=pm
XI14 Pb net011 A0 Y / pch_lvt nf=1 w=p_w m=pm
XP0 Pb P B0 net011 / pch_lvt nf=1 w=p_w m=pm
XP1 Pb P B1 net011 / pch_lvt nf=1 w=p_w m=pm
.ENDS

.SUBCKT zctl BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] DBL1 EN ENB GRST LCLKB LRST LXA[0] LXA[1] LXA[2] LXA[3] LXB[0]
+ LXB[1] LXB[2] LXB[3] LXC[0] LXC[1] LXC[2] LXC[3] LXWB[0] LXWB[1] LXWB[2]
+ LXWB[3] PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RBS[0] RBS[1] RBS[2] RBS[3] RM[0] RM[1] RM[2] RWOUT SPUI T1EN
+ VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WBS[0] WBS[1] WBS[2] WBS[3] WLRST
+ WM[0] WM[1] WM[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0]
+ XC[1] XC[2] XC[3] XWB[0] XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2]
+ YSEL[3] ZB ZB2 ZRR ag_ctrl
*.PININFO CSH_LD:I CSH_RR:I RM[0]:I RM[1]:I RM[2]:I WM[0]:I WM[1]:I WM[2]:I
*.PININFO ZB:I ZB2:I LXA[0]:O LXA[1]:O LXA[2]:O LXA[3]:O LXB[0]:O LXB[1]:O
*.PININFO LXB[2]:O LXB[3]:O LXC[0]:O LXC[1]:O LXC[2]:O LXC[3]:O LXWB[0]:O
*.PININFO LXWB[1]:O LXWB[2]:O LXWB[3]:O RBS[0]:O RBS[1]:O RBS[2]:O RBS[3]:O
*.PININFO WBS[0]:O WBS[1]:O WBS[2]:O WBS[3]:O BPUI:B CSH_ENB:B CSH_YS[0]:B
*.PININFO CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B DBL1:B EN:B ENB:B GRST:B LCLKB:B
*.PININFO LRST:B PWR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B
*.PININFO QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B RWOUT:B SPUI:B T1EN:B
*.PININFO VDDA:B VNW:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B WLRST:B
*.PININFO XA[0]:B XA[1]:B XA[2]:B XA[3]:B XB[0]:B XB[1]:B XB[2]:B XB[3]:B
*.PININFO XC[0]:B XC[1]:B XC[2]:B XC[3]:B XWB[0]:B XWB[1]:B XWB[2]:B XWB[3]:B
*.PININFO YSEL[0]:B YSEL[1]:B YSEL[2]:B YSEL[3]:B ZRR:B ag_ctrl:B
XI269 VSS bulk! bitieres a=4.655e-13 perim=2.88u cabar=1 sx_sw_local=-1
XD0 EN VSS / ant_diode nf=1 w=240nm m=1
XD1 ENB VSS / ant_diode nf=1 w=240nm m=1
XI181[0] LDECE[0] XC[0] VSS VSS PWR VNW net036[0] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI181[1] LDECE[0] XC[1] VSS VSS PWR VNW net036[1] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI181[2] LDECE[0] XC[2] VSS VSS PWR VNW net036[2] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI181[3] LDECE[0] XC[3] VSS VSS PWR VNW net036[3] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI239[0] LDECE[1] XB[0] VSS VSS PWR VNW net0121[0] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI239[1] LDECE[1] XB[1] VSS VSS PWR VNW net0121[1] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI239[2] LDECE[1] XB[2] VSS VSS PWR VNW net0121[2] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI239[3] LDECE[1] XB[3] VSS VSS PWR VNW net0121[3] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI240[0] LDECE[2] XA[0] VSS VSS PWR VNW net061[0] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI240[1] LDECE[2] XA[1] VSS VSS PWR VNW net061[1] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI240[2] LDECE[2] XA[2] VSS VSS PWR VNW net061[2] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI240[3] LDECE[2] XA[3] VSS VSS PWR VNW net061[3] / nand2 pm=1 p_w=360n nm=1
+ n_w=480n
XI244[0] ZB ZB2 ZRR VSS VSS PWR VNW LDECE[0] / nor3_lvt pm=1 p_w=1.08u nm=1
+ n_w=240n
XI244[1] ZB ZB2 ZRR VSS VSS PWR VNW LDECE[1] / nor3_lvt pm=1 p_w=1.08u nm=1
+ n_w=240n
XI244[2] ZB ZB2 ZRR VSS VSS PWR VNW LDECE[2] / nor3_lvt pm=1 p_w=1.08u nm=1
+ n_w=240n
XI258 CSH_RR RWOUT CSH_LD ZTC RWOUT VSS VSS PWR VNW net089 / aoi32_lvt pm=1
+ p_w=360n nm=1 n_w=480n
XI261 CSH_RR net0124 CSH_LD ZTC net0124 VSS VSS PWR VNW net0127 / aoi32_lvt
+ pm=1 p_w=360n nm=1 n_w=480n
XI243 ZB2 ZB VSS VSS PWR VNW ZTC / nor2_lvt nm=1 n_w=240n pm=1 p_w=720n
XI254[0] VNW net0117[0] RCLK PWR / pch_lvt nf=1 w=360n m=1
XI254[1] VNW net0117[1] RCLK PWR / pch_lvt nf=1 w=360n m=1
XI254[2] VNW net0117[2] RCLK PWR / pch_lvt nf=1 w=360n m=1
XI254[3] VNW net0117[3] RCLK PWR / pch_lvt nf=1 w=360n m=1
XI255[0] VNW net0115[0] WCLK PWR / pch_lvt nf=1 w=360n m=1
XI255[1] VNW net0115[1] WCLK PWR / pch_lvt nf=1 w=360n m=1
XI255[2] VNW net0115[2] WCLK PWR / pch_lvt nf=1 w=360n m=1
XI255[3] VNW net0115[3] WCLK PWR / pch_lvt nf=1 w=360n m=1
XI233[0] VSS VSS net0132[0] ZXWB[0] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI233[1] VSS VSS net0132[1] ZXWB[1] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI233[2] VSS VSS net0132[2] ZXWB[2] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI233[3] VSS VSS net0132[3] ZXWB[3] PWR VNW / inv_lvt pm=2 p_w=360n nm=2
+ n_w=240n
XI228[0] VSS VSS net0133[0] LXWB[0] VDDA VNW / inv_lvt pm=2 p_w=1.08u nm=2
+ n_w=0.72u
XI228[1] VSS VSS net0133[1] LXWB[1] VDDA VNW / inv_lvt pm=2 p_w=1.08u nm=2
+ n_w=0.72u
XI228[2] VSS VSS net0133[2] LXWB[2] VDDA VNW / inv_lvt pm=2 p_w=1.08u nm=2
+ n_w=0.72u
XI228[3] VSS VSS net0133[3] LXWB[3] VDDA VNW / inv_lvt pm=2 p_w=1.08u nm=2
+ n_w=0.72u
XI211[0] VSS VSS net0123[0] WBS[0] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI211[1] VSS VSS net0123[1] WBS[1] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI211[2] VSS VSS net0123[2] WBS[2] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI211[3] VSS VSS net0123[3] WBS[3] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI238[0] VSS VSS net0125[0] RBS[0] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI238[1] VSS VSS net0125[1] RBS[1] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI238[2] VSS VSS net0125[2] RBS[2] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI238[3] VSS VSS net0125[3] RBS[3] PWR VNW / inv_lvt pm=8 p_w=900n nm=8
+ n_w=600n
XI260 VSS VSS net089 WCLK PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI259 VSS VSS net0127 RCLK PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI106[0] VSS VSS net036[0] LXC[0] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI106[1] VSS VSS net036[1] LXC[1] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI106[2] VSS VSS net036[2] LXC[2] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI106[3] VSS VSS net036[3] LXC[3] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI262 VSS VSS RWOUT net0124 PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI251[0] net088 VSS YSEL[0] net0115[0] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI251[1] net088 VSS YSEL[1] net0115[1] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI251[2] net088 VSS YSEL[2] net0115[2] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI251[3] net088 VSS YSEL[3] net0115[3] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI109[0] VSS VSS net0121[0] LXB[0] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI109[1] VSS VSS net0121[1] LXB[1] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI109[2] VSS VSS net0121[2] LXB[2] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI109[3] VSS VSS net0121[3] LXB[3] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI113[0] VSS VSS net061[0] LXA[0] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI113[1] VSS VSS net061[1] LXA[1] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI113[2] VSS VSS net061[2] LXA[2] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI113[3] VSS VSS net061[3] LXA[3] PWR VNW / inv_lvt pm=2 p_w=0.81u nm=2
+ n_w=0.54u
XI250[0] net0105 VSS YSEL[0] net0117[0] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI250[1] net0105 VSS YSEL[1] net0117[1] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI250[2] net0105 VSS YSEL[2] net0117[2] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI250[3] net0105 VSS YSEL[3] net0117[3] PWR VNW / inv_lvt pm=1 p_w=360n nm=1
+ n_w=240n
XI232[0] WLRST XWB[0] VSS VSS PWR VNW net0132[0] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI232[1] WLRST XWB[1] VSS VSS PWR VNW net0132[1] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI232[2] WLRST XWB[2] VSS VSS PWR VNW net0132[2] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI232[3] WLRST XWB[3] VSS VSS PWR VNW net0132[3] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI229[0] ZCSH ZXWB[0] VSS VSS PWR VNW net0133[0] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI229[1] ZCSH ZXWB[1] VSS VSS PWR VNW net0133[1] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI229[2] ZCSH ZXWB[2] VSS VSS PWR VNW net0133[2] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI229[3] ZCSH ZXWB[3] VSS VSS PWR VNW net0133[3] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI263 CSH_RR CSH_LD ZTC VSS VSS VDDA VNW ZCSH / aoi21_lvt pm=1 p_w=360n nm=1
+ n_w=480n
XI234[0] VSS VSS net0118[0] net0120[0] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI234[1] VSS VSS net0118[1] net0120[1] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI234[2] VSS VSS net0118[2] net0120[2] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI234[3] VSS VSS net0118[3] net0120[3] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI246[0] VSS VSS net0117[0] net0108[0] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI246[1] VSS VSS net0117[1] net0108[1] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI246[2] VSS VSS net0117[2] net0108[2] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI246[3] VSS VSS net0117[3] net0108[3] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI235[0] VSS VSS net0115[0] net0118[0] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI235[1] VSS VSS net0115[1] net0118[1] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI235[2] VSS VSS net0115[2] net0118[2] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI235[3] VSS VSS net0115[3] net0118[3] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI247[0] VSS VSS net0108[0] net0111[0] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI247[1] VSS VSS net0108[1] net0111[1] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI247[2] VSS VSS net0108[2] net0111[2] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI247[3] VSS VSS net0108[3] net0111[3] PWR VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=360n
XI248[0] net0117[0] net0111[0] VSS VSS PWR VNW net0125[0] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI248[1] net0117[1] net0111[1] VSS VSS PWR VNW net0125[1] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI248[2] net0117[2] net0111[2] VSS VSS PWR VNW net0125[2] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI248[3] net0117[3] net0111[3] VSS VSS PWR VNW net0125[3] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI236[0] net0115[0] net0120[0] VSS VSS PWR VNW net0123[0] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI236[1] net0115[1] net0120[1] VSS VSS PWR VNW net0123[1] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI236[2] net0115[2] net0120[2] VSS VSS PWR VNW net0123[2] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI236[3] net0115[3] net0120[3] VSS VSS PWR VNW net0123[3] / nand2_lvt pm=3
+ p_w=360n nm=3 n_w=480n
XI252 VSS VSS RCLK net0105 / nch_lvt nf=1 w=240n m=1
XI253 VSS net088 WCLK VSS / nch_lvt nf=1 w=240n m=1
.ENDS

.SUBCKT sactl_pg BPU BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] EN ENB GRST LRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+ QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2] RWOUT SPU SPUI T1EN VDDA
+ VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLRST WM[0] WM[1] WM[2] XA[0] XA[1]
+ XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3] XWB[0] XWB[1]
+ XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] ZB2 ZRR ag_ctrl
*.PININFO BPU:B BPUI:B CSH_ENB:B CSH_LD:B CSH_RR:B CSH_YS[0]:B CSH_YS[1]:B
*.PININFO CSH_YS[2]:B CSH_YS[3]:B EN:B ENB:B GRST:B LRST:B PWR:B QT[2]:B
*.PININFO QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B
*.PININFO QT[11]:B QT[12]:B QT[13]:B RM[0]:B RM[1]:B RM[2]:B RWOUT:B SPU:B
*.PININFO SPUI:B T1EN:B VDDA:B VNW:B VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B VSS:B
*.PININFO WLRST:B WM[0]:B WM[1]:B WM[2]:B XA[0]:B XA[1]:B XA[2]:B XA[3]:B
*.PININFO XB[0]:B XB[1]:B XB[2]:B XB[3]:B XC[0]:B XC[1]:B XC[2]:B XC[3]:B
*.PININFO XWB[0]:B XWB[1]:B XWB[2]:B XWB[3]:B YSEL[0]:B YSEL[1]:B YSEL[2]:B
*.PININFO YSEL[3]:B ZB2:B ZRR:B ag_ctrl:B
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
XI248 VSS VSS net019 SPU VDDA VNW / inv_svt nm=4 n_w=480n pm=4 p_w=720n
XI247 VSS VSS SPUI net019 VDDA VNW / inv_svt nm=1 n_w=480n pm=1 p_w=720n
XI243 VSS VSS BPUI BPU VDDA VNW / inv_svt nm=4 n_w=480n pm=4 p_w=720n
XI249[0] BPU PWR VDDA VNW VSS / giopg
XI249[1] BPU PWR VDDA VNW VSS / giopg
XI249[2] BPU PWR VDDA VNW VSS / giopg
XI249[3] BPU PWR VDDA VNW VSS / giopg
XI249[4] BPU PWR VDDA VNW VSS / giopg
XI249[5] BPU PWR VDDA VNW VSS / giopg
XI249[6] BPU PWR VDDA VNW VSS / giopg
XI249[7] BPU PWR VDDA VNW VSS / giopg
.ENDS

.SUBCKT sactl_sb AG BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] EN ENB GRST LRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+ QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2] RWOUT SB[1] SB[2] SB[3]
+ SB[4] SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLRST WM[0] WM[1]
+ WM[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2]
+ XC[3] XWB[0] XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] ZB2 ZRR
+ ag_ctrl
*.PININFO AG:B BPUI:B CSH_ENB:B CSH_LD:B CSH_RR:B CSH_YS[0]:B CSH_YS[1]:B
*.PININFO CSH_YS[2]:B CSH_YS[3]:B EN:B ENB:B GRST:B LRST:B PWR:B QT[2]:B
*.PININFO QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B
*.PININFO QT[11]:B QT[12]:B QT[13]:B RM[0]:B RM[1]:B RM[2]:B RWOUT:B SB[1]:B
*.PININFO SB[2]:B SB[3]:B SB[4]:B SPUI:B T1EN:B VDDA:B VNW:B VSB[1]:B VSB[2]:B
*.PININFO VSB[3]:B VSB[4]:B VSS:B WLRST:B WM[0]:B WM[1]:B WM[2]:B XA[0]:B
*.PININFO XA[1]:B XA[2]:B XA[3]:B XB[0]:B XB[1]:B XB[2]:B XB[3]:B XC[0]:B
*.PININFO XC[1]:B XC[2]:B XC[3]:B XWB[0]:B XWB[1]:B XWB[2]:B XWB[3]:B
*.PININFO YSEL[0]:B YSEL[1]:B YSEL[2]:B YSEL[3]:B ZB2:B ZRR:B ag_ctrl:B
XI241 VSS VSS ag_ctrl AG VDDA VNW / inv_svt nm=4 n_w=640n pm=4 p_w=640n
XI243[1] VSS VSS VSB[1] net012[0] VDDA VNW / inv_svt nm=1 n_w=480n pm=1
+ p_w=960n
XI243[2] VSS VSS VSB[2] net012[1] VDDA VNW / inv_svt nm=1 n_w=480n pm=1
+ p_w=960n
XI243[3] VSS VSS VSB[3] net012[2] VDDA VNW / inv_svt nm=1 n_w=480n pm=1
+ p_w=960n
XI243[4] VSS VSS VSB[4] net012[3] VDDA VNW / inv_svt nm=1 n_w=480n pm=1
+ p_w=960n
XI242[1] VSS VSS net012[0] SB[1] VDDA VNW / inv_svt nm=4 n_w=320n pm=4 p_w=640n
XI242[2] VSS VSS net012[1] SB[2] VDDA VNW / inv_svt nm=4 n_w=320n pm=4 p_w=640n
XI242[3] VSS VSS net012[2] SB[3] VDDA VNW / inv_svt nm=4 n_w=320n pm=4 p_w=640n
XI242[4] VSS VSS net012[3] SB[4] VDDA VNW / inv_svt nm=4 n_w=320n pm=4 p_w=640n
.ENDS

.SUBCKT lsa_colmux_cm2 BB[0] BBMX BT[0] BTMX PWR RB VNW VSS WB WBLB WBLT
*.PININFO RB:I WB:I WBLB:I WBLT:I BB[0]:B BBMX:B BT[0]:B BTMX:B PWR:B VNW:B
*.PININFO VSS:B
XI76 VNW PWR PRCHB BB[0] / pch_lvtx nf=1 w=500n m=4
XI78 VNW BT[0] RB BTMX / pch_lvtx nf=1 w=360n m=2
XI54 VNW BB[0] PRCHB BT[0] / pch_lvtx nf=1 w=500n m=1
XI77 VNW BB[0] RB BBMX / pch_lvtx nf=1 w=360n m=2
XI75 VNW PWR PRCHB BT[0] / pch_lvtx nf=1 w=500n m=4
XI43 VSS BB[0] WT WBLB / nch_svtx nf=1 w=550n m=1
XI42 VSS BT[0] WT WBLT / nch_svtx nf=1 w=550n m=1
XI64 VSS VSS WB WT PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=200n
XI62 WB RB VSS VSS PWR VNW PRCHB / nand2 pm=1 p_w=360n nm=1 n_w=360n
.ENDS

.SUBCKT lmx_4to1cm4 BB[0] BB[1] BB[2] BB[3] BBMX BT[0] BT[1] BT[2] BT[3] BTMX
+ LDB LDT PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1]
+ WBS[2] WBS[3]
*.PININFO LDB:I LDT:I BB[0]:B BB[1]:B BB[2]:B BB[3]:B BBMX:B BT[0]:B BT[1]:B
*.PININFO BT[2]:B BT[3]:B BTMX:B PWR:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B
*.PININFO VDDA:B VNW:B VSS:B VSSX:B WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B
XXI3 BB[3] BBMX BT[3] BTMX PWR RBS[3] VNW VSS WBS[3] LDB LDT / lsa_colmux_cm2
XXI2 BB[2] BBMX BT[2] BTMX PWR RBS[2] VNW VSS WBS[2] LDB LDT / lsa_colmux_cm2
XXI0 BB[0] BBMX BT[0] BTMX PWR RBS[0] VNW VSS WBS[0] LDB LDT / lsa_colmux_cm2
XXI1 BB[1] BBMX BT[1] BTMX PWR RBS[1] VNW VSS WBS[1] LDB LDT / lsa_colmux_cm2
.ENDS

.SUBCKT lmx_cm4x1 BB[0] BB[1] BB[2] BB[3] BBMX[0] BT[0] BT[1] BT[2] BT[3]
+ BTMX[0] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] LDB[0] LDT[0] PWR RBS[0]
+ RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1] WBS[2] WBS[3]
*.PININFO LDB[0]:I LDT[0]:I BB[0]:B BB[1]:B BB[2]:B BB[3]:B BBMX[0]:B BT[0]:B
*.PININFO BT[1]:B BT[2]:B BT[3]:B BTMX[0]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B PWR:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B VDDA:B
*.PININFO VNW:B VSS:B VSSX:B WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B
XXI0 BB[0] BB[1] BB[2] BB[3] BBMX[0] BT[0] BT[1] BT[2] BT[3] BTMX[0] LDB[0]
+ LDT[0] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1]
+ WBS[2] WBS[3] / lmx_4to1cm4
.ENDS

.SUBCKT lio_sb_rebuf AG AGI PWR SB[1] SB[2] SB[3] SB[4] SBI[1] SBI[2] SBI[3]
+ SBI[4] VDDA VNW VSS
*.PININFO AG:B AGI:B PWR:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B SBI[1]:B SBI[2]:B
*.PININFO SBI[3]:B SBI[4]:B VDDA:B VNW:B VSS:B
XI34 VSS VSS net025 AG VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI242[1] VSS VSS net027[0] SB[1] VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI242[2] VSS VSS net027[1] SB[2] VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI242[3] VSS VSS net027[2] SB[3] VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI242[4] VSS VSS net027[3] SB[4] VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI243[1] VSS VSS SBI[1] net027[0] VDDA VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=480n
XI243[2] VSS VSS SBI[2] net027[1] VDDA VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=480n
XI243[3] VSS VSS SBI[3] net027[2] VDDA VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=480n
XI243[4] VSS VSS SBI[4] net027[3] VDDA VNW / inv_svt nm=1 n_w=240n pm=1
+ p_w=480n
XI35 VSS VSS AGI net025 VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
.ENDS

.SUBCKT sb_unit VSB1 VSB2 VSB3 VSB4 VSS VSSX
*.PININFO VSB1:I VSB2:I VSB3:I VSB4:I VSS:B VSSX:B
MN2 VSSX VSB1 net014 bulk! d_tonfet m=1 l=112.00n w=312.00n nf=1 par=1 gcon=1
+ optNum=0 diffL=168.00n diffM=224.00n diffR=168.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.359 nrd=0.359
MN1 net014 VSB1 net73 bulk! d_tonfet m=1 l=112.00n w=312.00n nf=1 par=1 gcon=1
+ optNum=0 diffL=168.00n diffM=224.00n diffR=168.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.359 nrd=0.359
MN0 net73 VSB1 VSS bulk! d_tonfet m=1 l=112.00n w=312.00n nf=1 par=1 gcon=1
+ optNum=0 diffL=168.00n diffM=224.00n diffR=168.00n composite=0 local_sigma=0
+ pu0mult=1e35 pla=0.0 pcpitch=1 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.359 nrd=0.359
XI32 VSS VSSX VSSX net71 / nch_lvt nf=1 w=500nm m=1
XI31 VSS net71 VSB3 VSS / nch_lvt nf=1 w=190n m=1
XI30 VSS net72 VSB2 VSS / nch_lvt nf=1 w=190n m=1
XI29 VSS VSSX VSSX net72 / nch_lvt nf=1 w=1u m=4
XI34 VSS net70 VSB4 VSS / nch_svt nf=1 w=190n m=1
XI36 VSS VSSX VSSX net70 / nch_svt nf=1 w=190n m=1
.ENDS

.SUBCKT footer_unit AG VDDA VNW VSS VSSX
*.PININFO AG:B VDDA:B VNW:B VSS:B VSSX:B
XI2 VSS VSSX gate VSS / nch_svtx nf=1 w=700n m=6
XI3 VSS VSS AG gate VDDA VNW / inv pm=1 p_w=480n nm=1 n_w=240n
.ENDS

.SUBCKT lio_sb4_64 AG BBMX[0] BTMX[0] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ LDB[0] LDT[0] PWR SB[1] SB[2] SB[3] SB[4] VDDA VNW VSS VSSX
*.PININFO AG:B BBMX[0]:B BTMX[0]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.PININFO GRD0[3]:B LDB[0]:B LDT[0]:B PWR:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B
*.PININFO VDDA:B VNW:B VSS:B VSSX:B
Xsb[0] SB[1] SB[2] SB[3] SB[4] VSS VSSX / sb_unit
Xag[0] AG VDDA VNW VSS VSSX / footer_unit
.ENDS

.SUBCKT lio_pg16 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BPU BTMX[0] BTMX[1] BTMX[2]
+ BTMX[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SPU VDDA VNW VSS
+ VSSX
*.PININFO BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BPU:B BTMX[0]:B BTMX[1]:B
*.PININFO BTMX[2]:B BTMX[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.PININFO GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B
*.PININFO GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.PININFO GRD3[3]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDT[0]:B LDT[1]:B
*.PININFO LDT[2]:B LDT[3]:B PWR:B SPU:B VDDA:B VNW:B VSS:B VSSX:B
XXPG[0] BPU PWR VDDA VNW VSS / giopg
XXPG[1] BPU PWR VDDA VNW VSS / giopg
XXPG[2] BPU PWR VDDA VNW VSS / giopg
XXPG[3] BPU PWR VDDA VNW VSS / giopg
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
.ENDS

.SUBCKT lmx_rebuf PWR RBS[0] RBS[1] RBS[2] RBS[3] RBSI[0] RBSI[1] RBSI[2]
+ RBSI[3] VDDA VNW VSS WBS[0] WBS[1] WBS[2] WBS[3] WBSI[0] WBSI[1] WBSI[2]
+ WBSI[3]
*.PININFO PWR:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B RBSI[0]:B RBSI[1]:B
*.PININFO RBSI[2]:B RBSI[3]:B VDDA:B VNW:B VSS:B WBS[0]:B WBS[1]:B WBS[2]:B
*.PININFO WBS[3]:B WBSI[0]:B WBSI[1]:B WBSI[2]:B WBSI[3]:B
XI13[0] VSS VSS WBSI[0] net028[0] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI13[1] VSS VSS WBSI[1] net028[1] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI13[2] VSS VSS WBSI[2] net028[2] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI13[3] VSS VSS WBSI[3] net028[3] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[0] VSS VSS RBSI[0] net027[0] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[1] VSS VSS RBSI[1] net027[1] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[2] VSS VSS RBSI[2] net027[2] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[3] VSS VSS RBSI[3] net027[3] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI11[0] VSS VSS net027[0] RBS[0] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[1] VSS VSS net027[1] RBS[1] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[2] VSS VSS net027[2] RBS[2] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[3] VSS VSS net027[3] RBS[3] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14[0] VSS VSS net028[0] WBS[0] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14[1] VSS VSS net028[1] WBS[1] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14[2] VSS VSS net028[2] WBS[2] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14[3] VSS VSS net028[3] WBS[3] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
.ENDS

.SUBCKT lio_sb16_64 AG BBMX[0] BBMX[1] BBMX[2] BBMX[3] BTMX[0] BTMX[1] BTMX[2]
+ BTMX[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SB[1] SB[2]
+ SB[3] SB[4] VDDA VNW VSS VSSX
*.PININFO AG:B BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BTMX[0]:B BTMX[1]:B
*.PININFO BTMX[2]:B BTMX[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.PININFO GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B
*.PININFO GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.PININFO GRD3[3]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDT[0]:B LDT[1]:B
*.PININFO LDT[2]:B LDT[3]:B PWR:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B VDDA:B VNW:B
*.PININFO VSS:B VSSX:B
Xsb[0] SB[1] SB[2] SB[3] SB[4] VSS VSSX / sb_unit
Xsb[1] SB[1] SB[2] SB[3] SB[4] VSS VSSX / sb_unit
Xsb[2] SB[1] SB[2] SB[3] SB[4] VSS VSSX / sb_unit
Xsb[3] SB[1] SB[2] SB[3] SB[4] VSS VSSX / sb_unit
Xag[0] AG VDDA VNW VSS VSSX / footer_unit
Xag[1] AG VDDA VNW VSS VSSX / footer_unit
Xag[2] AG VDDA VNW VSS VSSX / footer_unit
Xag[3] AG VDDA VNW VSS VSSX / footer_unit
.ENDS

.SUBCKT lio_sb8_64 AG BBMX[0] BBMX[1] BTMX[0] BTMX[1] GBW GD GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] LDB[0] LDB[1] LDT[0] LDT[1]
+ PWR SB[1] SB[2] SB[3] SB[4] VDDA VNW VSS VSSX
*.PININFO AG:B BBMX[0]:B BBMX[1]:B BTMX[0]:B BTMX[1]:B GBW:B GD:B GRD0[0]:B
*.PININFO GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B
*.PININFO GRD1[3]:B LDB[0]:B LDB[1]:B LDT[0]:B LDT[1]:B PWR:B SB[1]:B SB[2]:B
*.PININFO SB[3]:B SB[4]:B VDDA:B VNW:B VSS:B VSSX:B
Xsb[0] SB[1] SB[2] SB[3] SB[4] VSS VSSX / sb_unit
Xsb[1] SB[1] SB[2] SB[3] SB[4] VSS VSSX / sb_unit
Xag[0] AG VDDA VNW VSS VSSX / footer_unit
Xag[1] AG VDDA VNW VSS VSSX / footer_unit
.ENDS

.SUBCKT lio_sb_edge AG PWR SB[1] SB[2] SB[3] SB[4] VDDA VNW VSS
*.PININFO AG:B PWR:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT lmx_edge PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS WBS[0] WBS[1]
+ WBS[2] WBS[3]
*.PININFO PWR:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B VDDA:B VNW:B VSS:B
*.PININFO WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B
.ENDS

.SUBCKT lmx_cm4x4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+ BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BBMX[0] BBMX[1] BBMX[2] BBMX[3]
+ BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11]
+ BT[12] BT[13] BT[14] BT[15] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GBW GD GRD0[0]
+ GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1]
+ GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3]
+ LDT[0] LDT[1] LDT[2] LDT[3] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS
+ VSSX WBS[0] WBS[1] WBS[2] WBS[3]
*.PININFO LDB[0]:I LDB[1]:I LDB[2]:I LDB[3]:I LDT[0]:I LDT[1]:I LDT[2]:I
*.PININFO LDT[3]:I BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B
*.PININFO BB[7]:B BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.PININFO BB[15]:B BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BT[0]:B BT[1]:B
*.PININFO BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B BT[9]:B
*.PININFO BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B BTMX[0]:B
*.PININFO BTMX[1]:B BTMX[2]:B BTMX[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B
*.PININFO GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B
*.PININFO GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B
*.PININFO GRD3[2]:B GRD3[3]:B PWR:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B VDDA:B
*.PININFO VNW:B VSS:B VSSX:B WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B
XXI2 BB[8] BB[9] BB[10] BB[11] BBMX[2] BT[8] BT[9] BT[10] BT[11] BTMX[2]
+ LDB[2] LDT[2] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0]
+ WBS[1] WBS[2] WBS[3] / lmx_4to1cm4
XXI3 BB[12] BB[13] BB[14] BB[15] BBMX[3] BT[12] BT[13] BT[14] BT[15] BTMX[3]
+ LDB[3] LDT[3] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0]
+ WBS[1] WBS[2] WBS[3] / lmx_4to1cm4
XXI1 BB[4] BB[5] BB[6] BB[7] BBMX[1] BT[4] BT[5] BT[6] BT[7] BTMX[1] LDB[1]
+ LDT[1] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1]
+ WBS[2] WBS[3] / lmx_4to1cm4
XXI0 BB[0] BB[1] BB[2] BB[3] BBMX[0] BT[0] BT[1] BT[2] BT[3] BTMX[0] LDB[0]
+ LDT[0] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1]
+ WBS[2] WBS[3] / lmx_4to1cm4
.ENDS

.SUBCKT lsa2 BBMX BTMX CS PWR SAE SAOB SAOT SAPR VDDA VNW VSS
*.PININFO BBMX:B BTMX:B CS:B PWR:B SAE:B SAOB:B SAOT:B SAPR:B VDDA:B VNW:B
*.PININFO VSS:B
XT0 SAOB SAOT net062 bulk! net062 d_avtanfet_bc m=2 l=112.00n w=2.4u nf=2 par=2
+ gcon=1 optNum=0 diffL=156.00n diffM=224.00n diffR=156.00n diffB=274n
+ local_sigma=0 pu0mult=1e35 pla=0.0 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.0467 nrd=0.0467
XT1 SAOT SAOB net062 bulk! net062 d_avtanfet_bc m=2 l=112.00n w=2.4u nf=2 par=2
+ gcon=1 optNum=0 diffL=156.00n diffM=224.00n diffR=156.00n diffB=274n
+ local_sigma=0 pu0mult=1e35 pla=0.0 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.0467 nrd=0.0467
XI20 VSS VSS CS net059 PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI57 VSS net062 SAET1 VSS / nch_lvtx nf=1 w=550n m=1
XI70 VNW SAOT PCB SAOB / pch_lvtx nf=1 w=360n m=1
XI92 VNW SAOB SAET1 BBMX / pch_lvtx nf=1 w=480n m=1
XI91 VNW SAOT SAET1 BTMX / pch_lvtx nf=1 w=480n m=1
XI87 VNW PWR PCB SAOT / pch_lvtx nf=1 w=720n m=1
XI88 VNW PWR PCB SAOB / pch_lvtx nf=1 w=720n m=1
XI75 VNW PWR SAOB SAOT / pch_lvtx nf=1 w=480n m=1
XI74 VNW PWR SAOT SAOB / pch_lvtx nf=1 w=480n m=1
XI66 SAPR net059 VSS VSS PWR VNW PCB / nor2_lvtx pm=1 p_w=720n nm=1 n_w=240n
XI19 SAE net059 VSS VSS PWR VNW SAET1 / nor2_lvtx pm=1 p_w=720n nm=1 n_w=240n
.ENDS

.SUBCKT cache_lio_inv BBMX BTMX CS LRDB PWR SAE SAPR VDDA VNW VSS Z1 Z2 Z3
*.PININFO BBMX:I BTMX:I CS:B LRDB:B PWR:B SAE:B SAPR:B VDDA:B VNW:B VSS:B Z1:B
*.PININFO Z2:B Z3:B
XXSA BBMX BTMX CS PWR SAE saob saot SAPR VDDA VNW VSS / lsa2
XI39 Z1 saot VSS VSS PWR VNW Z2 / nand2 pm=1 p_w=360n nm=1 n_w=360n
XI37 Z2 saob VSS VSS PWR VNW Z1 / nand2 pm=1 p_w=360n nm=1 n_w=360n
XI142 VSS VSS Z3 LRDB PWR VNW / inv_lvt pm=2 p_w=720n nm=2 n_w=550n
.ENDS

.SUBCKT boost_module_na_64 BGND IN PWR VNW VSS WM[0] WM[1] WM[2]
*.PININFO WM[0]:I WM[1]:I WM[2]:I BGND:B IN:B PWR:B VNW:B VSS:B
XI66 VSS BGND IN VSS / nch_lvt nf=1 w=960n m=2
XI104 VSS BGND WM[0] net052 / nch_lvt nf=1 w=480n m=2
XI91 VSS BGND WM[2] net054 / nch_lvt nf=1 w=480n m=2
XI90 VSS BGND WM[1] net053 / nch_lvt nf=1 w=480n m=2
XI121 VSS VSS net024 z3 PWR VNW / inv_lvt pm=4 p_w=720n nm=4 n_w=480n
XI80 VSS VSS IN net024 PWR VNW / inv_lvt pm=2 p_w=360n nm=2 n_w=240n
XT2 net052 z3 net052 bulk! VSS d_avtmnfet_bc m=1 l=232.00n w=2.616u nf=4 par=1
+ gcon=1 optNum=0 diffL=156.00n diffM=224.00n diffR=156.00n diffB=274n
+ local_sigma=0 pu0mult=1e35 pla=0.0 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.0428 nrd=0.0428
XT0 net054 z3 net054 bulk! VSS d_avtmnfet_bc m=1 l=232.00n w=2.616u nf=4 par=1
+ gcon=1 optNum=0 diffL=156.00n diffM=224.00n diffR=156.00n diffB=274n
+ local_sigma=0 pu0mult=1e35 pla=0.0 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.0428 nrd=0.0428
XT1 net053 z3 net053 bulk! VSS d_avtmnfet_bc m=1 l=232.00n w=2.616u nf=4 par=1
+ gcon=1 optNum=0 diffL=156.00n diffM=224.00n diffR=156.00n diffB=274n
+ local_sigma=0 pu0mult=1e35 pla=0.0 pvta=0 plnest=1 plorient=1 pld200=1
+ pre_layout_local=-1 pdevdops=1 pdevlgeos=1 pdevwgeos=1 nrs=0.0428 nrd=0.0428
.ENDS

.SUBCKT write_boost1_64 BST BW CS[0] D DB PWR VNW VSS WB[0] WM[0] WM[1] WM[2]
+ WT[0]
*.PININFO BW:I CS[0]:I D:I DB:I WM[0]:I WM[1]:I WM[2]:I BST:B PWR:B VNW:B
*.PININFO VSS:B WB[0]:B WT[0]:B
XBM BGND net063 PWR VNW VSS WM[0] WM[1] WM[2] / boost_module_na_64
XI102[0] net09 net032 VSS VSS PWR VNW zt[0] / nor2 nm=1 n_w=240n pm=1 p_w=720n
XI64[0] net09 net076 VSS VSS PWR VNW zb[0] / nor2 nm=1 n_w=240n pm=1 p_w=720n
XI101[0] VSS WT[0] zt[0] BGND / nch_lvtx nf=1 w=480n m=2
XI27[0] VSS WB[0] zb[0] BGND / nch_lvtx nf=1 w=480n m=2
XI110 BW D VSS VSS PWR VNW net032 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI109 BW DB VSS VSS PWR VNW net076 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI79 BST BW VSS VSS PWR VNW net063 / nand2 pm=1 p_w=690n nm=1 n_w=930n
XI113[0] VSS VSS CS[0] net09 PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
.ENDS

.SUBCKT cache1_lio_64 BBMX[0] BSTB BTMX[0] CS[0] CS[1] CS[2] CS[3] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] LDB[0] LDT[0] LRD[0] PWR SAET SAPR VDDA VNW
+ VSS VSSX WM[0] WM[1] WM[2] Z1[0] Z2[0] Z3[0]
*.PININFO BBMX[0]:I BTMX[0]:I LDB[0]:O LDT[0]:O BSTB:B CS[0]:B CS[1]:B CS[2]:B
*.PININFO CS[3]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B LRD[0]:B
*.PININFO PWR:B SAET:B SAPR:B VDDA:B VNW:B VSS:B VSSX:B WM[0]:B WM[1]:B
*.PININFO WM[2]:B Z1[0]:B Z2[0]:B Z3[0]:B
XI163 VSS VSS BSTB BST PWR VNW / inv_lvt pm=2 p_w=360n nm=1 n_w=480n
XI156 VSS VSS GD GDB PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI159 VSS VSS SAPR SAPR_B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI140 VSS VSS SAET SAET_B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XXCA[0] BBMX[0] BTMX[0] PWR LRD[0] PWR SAET_B SAPR_B VDDA VNW VSS Z1[0] Z2[0]
+ Z3[0] / cache_lio_inv
Xxwdrv BST GBW PWR GDB GD PWR VNW VSS LDB[0] WM[0] WM[1] WM[2] LDT[0] /
+ write_boost1_64
.ENDS

.SUBCKT cache_rebuf BSTB BSTBI CS[0] CS[1] CS[2] CS[3] CSI[0] CSI[1] CSI[2]
+ CSI[3] PWR SAET SAETI SAPR SAPRI VDDA VNW VSS WM[0] WM[1] WM[2] WMI[0]
+ WMI[1] WMI[2]
*.PININFO BSTB:B BSTBI:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B CSI[0]:B CSI[1]:B
*.PININFO CSI[2]:B CSI[3]:B PWR:B SAET:B SAETI:B SAPR:B SAPRI:B VDDA:B VNW:B
*.PININFO VSS:B WM[0]:B WM[1]:B WM[2]:B WMI[0]:B WMI[1]:B WMI[2]:B
XI269 VSS bulk! bitieres a=4.655e-13 perim=2.88u cabar=1 sx_sw_local=-1
XI24[0] VSS VSS net043[0] WM[0] PWR VNW / inv_lvt pm=2 p_w=960n nm=2 n_w=480n
XI24[1] VSS VSS net043[1] WM[1] PWR VNW / inv_lvt pm=2 p_w=960n nm=2 n_w=480n
XI24[2] VSS VSS net043[2] WM[2] PWR VNW / inv_lvt pm=2 p_w=960n nm=2 n_w=480n
XI25[0] VSS VSS WMI[0] net043[0] PWR VNW / inv_lvt pm=1 p_w=480n nm=1 n_w=240n
XI25[1] VSS VSS WMI[1] net043[1] PWR VNW / inv_lvt pm=1 p_w=480n nm=1 n_w=240n
XI25[2] VSS VSS WMI[2] net043[2] PWR VNW / inv_lvt pm=1 p_w=480n nm=1 n_w=240n
XI23 VSS VSS net031 BSTB PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI22 VSS VSS BSTBI net031 PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI19 VSS VSS net025 SAPR PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI12[0] VSS VSS CSI[0] net027[0] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[1] VSS VSS CSI[1] net027[1] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[2] VSS VSS CSI[2] net027[2] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI12[3] VSS VSS CSI[3] net027[3] PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI20 VSS VSS SAPRI net025 PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
XI11[0] VSS VSS net027[0] CS[0] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[1] VSS VSS net027[1] CS[1] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[2] VSS VSS net027[2] CS[2] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI11[3] VSS VSS net027[3] CS[3] PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI14 VSS VSS net026 SAET PWR VNW / inv_lvt pm=4 p_w=960n nm=4 n_w=480n
XI13 VSS VSS SAETI net026 PWR VNW / inv_lvt pm=2 p_w=480n nm=2 n_w=240n
.ENDS

.SUBCKT lmx_cm4x2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BBMX[0]
+ BBMX[1] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BTMX[0] BTMX[1] GBW
+ GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] LDB[0]
+ LDB[1] LDT[0] LDT[1] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX
+ WBS[0] WBS[1] WBS[2] WBS[3]
*.PININFO LDB[0]:I LDB[1]:I LDT[0]:I LDT[1]:I BB[0]:B BB[1]:B BB[2]:B BB[3]:B
*.PININFO BB[4]:B BB[5]:B BB[6]:B BB[7]:B BBMX[0]:B BBMX[1]:B BT[0]:B BT[1]:B
*.PININFO BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BTMX[0]:B BTMX[1]:B
*.PININFO GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.PININFO GRD1[1]:B GRD1[2]:B GRD1[3]:B PWR:B RBS[0]:B RBS[1]:B RBS[2]:B
*.PININFO RBS[3]:B VDDA:B VNW:B VSS:B VSSX:B WBS[0]:B WBS[1]:B WBS[2]:B
*.PININFO WBS[3]:B
XXI3 BB[4] BB[5] BB[6] BB[7] BBMX[1] BT[4] BT[5] BT[6] BT[7] BTMX[1] LDB[1]
+ LDT[1] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1]
+ WBS[2] WBS[3] / lmx_4to1cm4
XXI0 BB[0] BB[1] BB[2] BB[3] BBMX[0] BT[0] BT[1] BT[2] BT[3] BTMX[0] LDB[0]
+ LDT[0] PWR RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1]
+ WBS[2] WBS[3] / lmx_4to1cm4
.ENDS

.SUBCKT lio_pg8 BBMX[0] BBMX[1] BPU BTMX[0] BTMX[1] GBW GD GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] LDB[0] LDB[1] LDT[0] LDT[1]
+ PWR SPU VDDA VNW VSS VSSX
*.PININFO BBMX[0]:B BBMX[1]:B BPU:B BTMX[0]:B BTMX[1]:B GBW:B GD:B GRD0[0]:B
*.PININFO GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B
*.PININFO GRD1[3]:B LDB[0]:B LDB[1]:B LDT[0]:B LDT[1]:B PWR:B SPU:B VDDA:B
*.PININFO VNW:B VSS:B VSSX:B
XXPG[0] BPU PWR VDDA VNW VSS / giopg
XXPG[1] BPU PWR VDDA VNW VSS / giopg
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
.ENDS

.SUBCKT lio_pg_rebuf BPU BPUI PWR SPU SPUI VDDA VNW VSS
*.PININFO BPU:B BPUI:B PWR:B SPU:B SPUI:B VDDA:B VNW:B VSS:B
XI34 VSS VSS net025 BPU VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI38 VSS VSS net019 SPU VDDA VNW / inv_svt nm=2 n_w=480n pm=2 p_w=960n
XI37 VSS VSS SPUI net019 VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
XI35 VSS VSS BPUI net025 VDDA VNW / inv_svt nm=1 n_w=240n pm=1 p_w=480n
.ENDS

.SUBCKT lio_pg4 BBMX[0] BPU BTMX[0] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ LDB[0] LDT[0] PWR SPU VDDA VNW VSS VSSX
*.PININFO BBMX[0]:B BPU:B BTMX[0]:B GBW:B GD:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.PININFO GRD0[3]:B LDB[0]:B LDT[0]:B PWR:B SPU:B VDDA:B VNW:B VSS:B VSSX:B
XXPG[0] BPU PWR VDDA VNW VSS / giopg
XI564 VNW VDDA SPU PWR / pch nf=1 w=600n m=1
.ENDS

.SUBCKT write_boost2_64 BST BW CS[0] CS[1] D DB PWR VNW VSS WB[0] WB[1] WM[0]
+ WM[1] WM[2] WT[0] WT[1]
*.PININFO BW:I CS[0]:I CS[1]:I D:I DB:I WM[0]:I WM[1]:I WM[2]:I BST:B PWR:B
*.PININFO VNW:B VSS:B WB[0]:B WB[1]:B WT[0]:B WT[1]:B
XBM BGND net063 PWR VNW VSS WM[0] WM[1] WM[2] / boost_module_na_64
XI102[0] net080[0] net032 VSS VSS PWR VNW zt[0] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI102[1] net080[1] net032 VSS VSS PWR VNW zt[1] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI64[0] net080[0] net076 VSS VSS PWR VNW zb[0] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI64[1] net080[1] net076 VSS VSS PWR VNW zb[1] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI27[0] VSS WB[0] zb[0] BGND / nch_lvtx nf=1 w=480n m=2
XI27[1] VSS WB[1] zb[1] BGND / nch_lvtx nf=1 w=480n m=2
XI101[0] VSS WT[0] zt[0] BGND / nch_lvtx nf=1 w=480n m=2
XI101[1] VSS WT[1] zt[1] BGND / nch_lvtx nf=1 w=480n m=2
XI110 BW D VSS VSS PWR VNW net032 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI109 BW DB VSS VSS PWR VNW net076 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI79 BST BW VSS VSS PWR VNW net063 / nand2 pm=1 p_w=690n nm=1 n_w=930n
XI113[0] VSS VSS CS[0] net080[0] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI113[1] VSS VSS CS[1] net080[1] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
.ENDS

.SUBCKT cache2_lio_64 BBMX[0] BBMX[1] BSTB BTMX[0] BTMX[1] CS[0] CS[1] CS[2]
+ CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ LDB[0] LDB[1] LDT[0] LDT[1] LRD[0] LRD[1] PWR SAET SAPR VDDA VNW VSS VSSX
+ WM[0] WM[1] WM[2] Z1[0] Z1[1] Z2[0] Z2[1] Z3[0] Z3[1]
*.PININFO BBMX[0]:I BBMX[1]:I BTMX[0]:I BTMX[1]:I LDB[0]:O LDB[1]:O LDT[0]:O
*.PININFO LDT[1]:O BSTB:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B GBW:B GD:B GRD0[0]:B
*.PININFO GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B
*.PININFO GRD1[3]:B LRD[0]:B LRD[1]:B PWR:B SAET:B SAPR:B VDDA:B VNW:B VSS:B
*.PININFO VSSX:B WM[0]:B WM[1]:B WM[2]:B Z1[0]:B Z1[1]:B Z2[0]:B Z2[1]:B
*.PININFO Z3[0]:B Z3[1]:B
Xxwdrv BST GBW CS[0] CS[1] GDB GD PWR VNW VSS LDB[0] LDB[1] WM[0] WM[1] WM[2]
+ LDT[0] LDT[1] / write_boost2_64
XI163 VSS VSS BSTB BST PWR VNW / inv_lvt pm=2 p_w=360n nm=1 n_w=480n
XI156 VSS VSS GD GDB PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI159 VSS VSS SAPR SAPR_B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI140 VSS VSS SAET SAET_B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XXCA[0] BBMX[0] BTMX[0] CS[0] LRD[0] PWR SAET_B SAPR_B VDDA VNW VSS Z1[0]
+ Z2[0] Z3[0] / cache_lio_inv
XXCA[1] BBMX[1] BTMX[1] CS[1] LRD[1] PWR SAET_B SAPR_B VDDA VNW VSS Z1[1]
+ Z2[1] Z3[1] / cache_lio_inv
.ENDS

.SUBCKT write_boost4_64 BST BW CS[0] CS[1] CS[2] CS[3] D DB PWR VNW VSS WB[0]
+ WB[1] WB[2] WB[3] WM[0] WM[1] WM[2] WT[0] WT[1] WT[2] WT[3]
*.PININFO BW:I CS[0]:I CS[1]:I CS[2]:I CS[3]:I D:I DB:I WM[0]:I WM[1]:I
*.PININFO WM[2]:I BST:B PWR:B VNW:B VSS:B WB[0]:B WB[1]:B WB[2]:B WB[3]:B
*.PININFO WT[0]:B WT[1]:B WT[2]:B WT[3]:B
XBM BGND net041 PWR VNW VSS WM[0] WM[1] WM[2] / boost_module_na_64
XI102[0] net023[0] net043 VSS VSS PWR VNW zt[0] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI102[1] net023[1] net043 VSS VSS PWR VNW zt[1] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI102[2] net023[2] net043 VSS VSS PWR VNW zt[2] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI102[3] net023[3] net043 VSS VSS PWR VNW zt[3] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI64[0] net023[0] net042 VSS VSS PWR VNW zb[0] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI64[1] net023[1] net042 VSS VSS PWR VNW zb[1] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI64[2] net023[2] net042 VSS VSS PWR VNW zb[2] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI64[3] net023[3] net042 VSS VSS PWR VNW zb[3] / nor2 nm=1 n_w=240n pm=1
+ p_w=720n
XI113[0] VSS VSS CS[0] net023[0] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI113[1] VSS VSS CS[1] net023[1] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI113[2] VSS VSS CS[2] net023[2] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI113[3] VSS VSS CS[3] net023[3] PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI109 BW DB VSS VSS PWR VNW net042 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI110 BW D VSS VSS PWR VNW net043 / nand2 pm=1 p_w=360n nm=1 n_w=480n
XI79 BST BW VSS VSS PWR VNW net041 / nand2 pm=1 p_w=690n nm=1 n_w=930n
XI101[0] VSS WT[0] zt[0] BGND / nch_lvt nf=1 w=480n m=2
XI101[1] VSS WT[1] zt[1] BGND / nch_lvt nf=1 w=480n m=2
XI101[2] VSS WT[2] zt[2] BGND / nch_lvt nf=1 w=480n m=2
XI101[3] VSS WT[3] zt[3] BGND / nch_lvt nf=1 w=480n m=2
XI27[0] VSS WB[0] zb[0] BGND / nch_lvt nf=1 w=480n m=2
XI27[1] VSS WB[1] zb[1] BGND / nch_lvt nf=1 w=480n m=2
XI27[2] VSS WB[2] zb[2] BGND / nch_lvt nf=1 w=480n m=2
XI27[3] VSS WB[3] zb[3] BGND / nch_lvt nf=1 w=480n m=2
.ENDS

.SUBCKT cache4_lio_64 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BSTB BTMX[0] BTMX[1]
+ BTMX[2] BTMX[3] CS[0] CS[1] CS[2] CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1]
+ LDT[2] LDT[3] LRD[0] LRD[1] LRD[2] LRD[3] PWR SAET SAPR VDDA VNW VSS VSSX
+ WM[0] WM[1] WM[2] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1] Z2[2] Z2[3] Z3[0]
+ Z3[1] Z3[2] Z3[3]
*.PININFO BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BSTB:B BTMX[0]:B BTMX[1]:B
*.PININFO BTMX[2]:B BTMX[3]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B GBW:B GD:B
*.PININFO GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B GRD1[1]:B
*.PININFO GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B
*.PININFO GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LDB[0]:B LDB[1]:B LDB[2]:B
*.PININFO LDB[3]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B LRD[0]:B LRD[1]:B
*.PININFO LRD[2]:B LRD[3]:B PWR:B SAET:B SAPR:B VDDA:B VNW:B VSS:B VSSX:B
*.PININFO WM[0]:B WM[1]:B WM[2]:B Z1[0]:B Z1[1]:B Z1[2]:B Z1[3]:B Z2[0]:B
*.PININFO Z2[1]:B Z2[2]:B Z2[3]:B Z3[0]:B Z3[1]:B Z3[2]:B Z3[3]:B
Xxwdrv BST GBW CS[0] CS[1] CS[2] CS[3] GDB GD PWR VNW VSS LDB[0] LDB[1] LDB[2]
+ LDB[3] WM[0] WM[1] WM[2] LDT[0] LDT[1] LDT[2] LDT[3] / write_boost4_64
XI163 VSS VSS BSTB BST PWR VNW / inv_lvt pm=2 p_w=360n nm=1 n_w=480n
XI156 VSS VSS GD GDB PWR VNW / inv_lvt pm=1 p_w=360n nm=1 n_w=240n
XI159 VSS VSS SAPR SAPR_B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XI140 VSS VSS SAET SAET_B PWR VNW / inv_lvt pm=1 p_w=720n nm=1 n_w=480n
XXCA[0] BBMX[0] BTMX[0] CS[0] LRD[0] PWR SAET_B SAPR_B VDDA VNW VSS Z1[0]
+ Z2[0] Z3[0] / cache_lio_inv
XXCA[1] BBMX[1] BTMX[1] CS[1] LRD[1] PWR SAET_B SAPR_B VDDA VNW VSS Z1[1]
+ Z2[1] Z3[1] / cache_lio_inv
XXCA[2] BBMX[2] BTMX[2] CS[2] LRD[2] PWR SAET_B SAPR_B VDDA VNW VSS Z1[2]
+ Z2[2] Z3[2] / cache_lio_inv
XXCA[3] BBMX[3] BTMX[3] CS[3] LRD[3] PWR SAET_B SAPR_B VDDA VNW VSS Z1[3]
+ Z2[3] Z3[3] / cache_lio_inv
.ENDS

.SUBCKT cache1_lio_edge BSTB CS[0] CS[1] CS[2] CS[3] PWR SAET SAPR VDDA VNW
+ VSS WM[0] WM[1] WM[2]
*.PININFO BSTB:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B PWR:B SAET:B SAPR:B VDDA:B
*.PININFO VNW:B VSS:B WM[0]:B WM[1]:B WM[2]:B
.ENDS

.SUBCKT cache2_lio_edge BSTB CS[0] CS[1] CS[2] CS[3] PWR SAET SAPR VDDA VNW
+ VSS WM[0] WM[1] WM[2]
*.PININFO BSTB:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B PWR:B SAET:B SAPR:B VDDA:B
*.PININFO VNW:B VSS:B WM[0]:B WM[1]:B WM[2]:B
.ENDS

.SUBCKT cache4_lio_edge BSTB CS[0] CS[1] CS[2] CS[3] PWR SAET SAPR VDDA VNW
+ VSS WM[0] WM[1] WM[2]
*.PININFO BSTB:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B PWR:B SAET:B SAPR:B VDDA:B
*.PININFO VNW:B VSS:B WM[0]:B WM[1]:B WM[2]:B
.ENDS

.SUBCKT lio_pg_edge BPU PWR SPU VDDA VNW VSS
*.PININFO BPU:B PWR:B SPU:B VDDA:B VNW:B VSS:B
.ENDS

.SUBCKT floorplan_lio
*.PININFO
XI55 net0743[0] net0743[1] net0743[2] net0743[3] net0836 net0828[0] net0828[1]
+ net0828[2] net0828[3] net0738 net0720 net0764 net0853[0] net0853[1]
+ net0853[2] net0853[3] net0670 net0804 net0762 net013[0] net013[1] net013[2]
+ net013[3] net0736 net014 net0791 net0729 net0659[0] net0659[1] net0659[2]
+ net0659[3] / lmx_cm4x1
XI51 net0827[0] net0827[1] net0827[2] net0827[3] net0705 net0707[0] net0707[1]
+ net0707[2] net0707[3] net0854 net0651 net0640 net0793[0] net0793[1]
+ net0793[2] net0793[3] net0843 net0661 net031 net029[0] net029[1] net029[2]
+ net029[3] net0752 net030 net0790 net032 net0811[0] net0811[1] net0811[2]
+ net0811[3] / lmx_cm4x1
XI43 net0797[0] net0797[1] net0797[2] net0797[3] net0710 net0809[0] net0809[1]
+ net0809[2] net0809[3] net065 net068 net069 net070[0] net070[1] net070[2]
+ net070[3] net066 net0785 net0632 net0625[0] net0625[1] net0625[2] net0625[3]
+ net0629 net0637 net0769 net0680 net067[0] net067[1] net067[2] net067[3] /
+ lmx_cm4x1
XI30 net026[0] net026[1] net026[2] net026[3] net025 net024[0] net024[1]
+ net024[2] net024[3] net0406 net020 net021 net022[0] net022[1] net022[2]
+ net022[3] net0383 net023 net0200 net027[0] net027[1] net027[2] net027[3]
+ net0197 net0202 net0198 net028 net019[0] net019[1] net019[2] net019[3] /
+ lmx_cm4x1
XI26 net0404[0] net0404[1] net0404[2] net0404[3] net0354 net04[0] net04[1]
+ net04[2] net04[3] net01 net0391 net0360 net0373[0] net0373[1] net0373[2]
+ net0373[3] net0389 net0375 net0152 net0399[0] net0399[1] net0399[2]
+ net0399[3] net0149 net0154 net0150 net0392 net0376[0] net0376[1] net0376[2]
+ net0376[3] / lmx_cm4x1
XI5 net042[0] net042[1] net042[2] net042[3] net041 net040[0] net040[1]
+ net040[2] net040[3] net033 net036 net037 net038[0] net038[1] net038[2]
+ net038[3] net034 net039 net106 net043[0] net043[1] net043[2] net043[3]
+ net102 net103 net104 net044 net035[0] net035[1] net035[2] net035[3] /
+ lmx_cm4x1
XI34 net0405 net0403 net018 net052[0] net052[1] net052[2] net052[3] net0380[0]
+ net0380[1] net0380[2] net0380[3] net016 net017 net015 / lio_sb_rebuf
XI53 net0108 net0840 net0783 net0109 net0110 net0848[0] net0848[1] net0848[2]
+ net0848[3] net0844 net0814 net0753 net0815[0] net0815[1] net0815[2]
+ net0815[3] net0658 net0111 net0852 net0678 / lio_sb4_64
XI28 net060 net062 net057 net0231 net0233 net0388[0] net0388[1] net0388[2]
+ net0388[3] net0387 net0369 net0232 net0397[0] net0397[1] net0397[2]
+ net0397[3] net0228 net0229 net0230 net064 / lio_sb4_64
XI47 net0778[0] net0778[1] net0778[2] net0778[3] net0139 net0839[0] net0839[1]
+ net0839[2] net0839[3] net0136 net0137 net0855[0] net0855[1] net0855[2]
+ net0855[3] net0845[0] net0845[1] net0845[2] net0845[3] net0628[0] net0628[1]
+ net0628[2] net0628[3] net0774[0] net0774[1] net0774[2] net0774[3] net0685[0]
+ net0685[1] net0685[2] net0685[3] net0141[0] net0141[1] net0141[2] net0141[3]
+ net0816 net0143 net0142 net0138 net0140 net0675 / lio_pg16
XI9 net077[0] net077[1] net077[2] net077[3] net071 net074[0] net074[1]
+ net074[2] net074[3] net96 net98 net91[0] net91[1] net91[2] net91[3]
+ net073[0] net073[1] net073[2] net073[3] net078[0] net078[1] net078[2]
+ net078[3] net076[0] net076[1] net076[2] net076[3] net079[0] net079[1]
+ net079[2] net079[3] net075[0] net075[1] net075[2] net075[3] net97 net072
+ net93 net94 net95 net080 / lio_pg16
XI73 net0892 net01068[0] net01068[1] net01068[2] net01068[3] net01092[0]
+ net01092[1] net01092[2] net01092[3] net01091 net01019 net0870 net0969[0]
+ net0969[1] net0969[2] net0969[3] net01077[0] net01077[1] net01077[2]
+ net01077[3] / lmx_rebuf
XI35 net06 net0350[0] net0350[1] net0350[2] net0350[3] net090[0] net090[1]
+ net090[2] net090[3] net03 net05 net02 net089[0] net089[1] net089[2]
+ net089[3] net088[0] net088[1] net088[2] net088[3] / lmx_rebuf
XI32 net0302 net099[0] net099[1] net099[2] net099[3] net0378[0] net0378[1]
+ net0378[2] net0378[3] net0327 net0264 net0331 net0393[0] net0393[1]
+ net0393[2] net0393[3] net0362[0] net0362[1] net0362[2] net0362[3] / lmx_rebuf
XI0 net6 net0107[0] net0107[1] net0107[2] net0107[3] net0106[0] net0106[1]
+ net0106[2] net0106[3] net3 net5 net2 net0105[0] net0105[1] net0105[2]
+ net0105[3] net0104[0] net0104[1] net0104[2] net0104[3] / lmx_rebuf
XI56 net0768 net0745[0] net0745[1] net0745[2] net0745[3] net0761[0] net0761[1]
+ net0761[2] net0761[3] net0742 net0688 net0755[0] net0755[1] net0755[2]
+ net0755[3] net0831[0] net0831[1] net0831[2] net0831[3] net0807[0] net0807[1]
+ net0807[2] net0807[3] net0667[0] net0667[1] net0667[2] net0667[3] net0751[0]
+ net0751[1] net0751[2] net0751[3] net0750[0] net0750[1] net0750[2] net0750[3]
+ net0824 net0780[0] net0780[1] net0780[2] net0780[3] net0784 net0770 net0692
+ net0837 / lio_sb16_64
XI37 net0112 net0353[0] net0353[1] net0353[2] net0353[3] net0116[0] net0116[1]
+ net0116[2] net0116[3] net0117 net0396 net0114[0] net0114[1] net0114[2]
+ net0114[3] net0115[0] net0115[1] net0115[2] net0115[3] net0125[0] net0125[1]
+ net0125[2] net0125[3] net0351[0] net0351[1] net0351[2] net0351[3] net0126[0]
+ net0126[1] net0126[2] net0126[3] net0366[0] net0366[1] net0366[2] net0366[3]
+ net0127 net0113[0] net0113[1] net0113[2] net0113[3] net0348 net0386 net0120
+ net0128 / lio_sb16_64
XI46 net0225 net0810[0] net0810[1] net0701[0] net0701[1] net0226 net0227
+ net0706[0] net0706[1] net0706[2] net0706[3] net0646[0] net0646[1] net0646[2]
+ net0646[3] net0765[0] net0765[1] net0833[0] net0833[1] net0798 net0763[0]
+ net0763[1] net0763[2] net0763[3] net0634 net0652 net0788 net0699 / lio_sb8_64
XI23 net0129 net0132[0] net0132[1] net0134[0] net0134[1] net096 net098
+ net091[0] net091[1] net091[2] net091[3] net0170[0] net0170[1] net0170[2]
+ net0170[3] net0133[0] net0133[1] net0131[0] net0131[1] net097 net0130[0]
+ net0130[1] net0130[2] net0130[3] net093 net094 net095 net0135 / lio_sb8_64
XI68 net01062 net0897 net0990[0] net0990[1] net0990[2] net0990[3] net0985
+ net0878 net01045 / lio_sb_edge
XI61 net0952 net0930 net0103[0] net0103[1] net0103[2] net0103[3] net0102
+ net0100 net0101 / lio_sb_edge
XI72 net01097 net0950[0] net0950[1] net0950[2] net0950[3] net01010 net0613
+ net0908 net0779[0] net0779[1] net0779[2] net0779[3] / lmx_edge
XI66 net0620 net0618[0] net0618[1] net0618[2] net0618[3] net0617 net0619
+ net0616 net0615[0] net0615[1] net0615[2] net0615[3] / lmx_edge
XI63 net0959 net0960[0] net0960[1] net0960[2] net0960[3] net0835 net0792
+ net0881 net0979[0] net0979[1] net0979[2] net0979[3] / lmx_edge
XI59 net0740 net0626[0] net0626[1] net0626[2] net0626[3] net0975 net0627
+ net0624 net0623[0] net0623[1] net0623[2] net0623[3] / lmx_edge
XI31 net012 net0636[0] net0636[1] net0636[2] net0636[3] net010 net011 net09
+ net0976[0] net0976[1] net0976[2] net0976[3] / lmx_edge
XI3 net12 net0630[0] net0630[1] net0630[2] net0630[3] net10 net11 net9
+ net0970[0] net0970[1] net0970[2] net0970[3] / lmx_edge
XI58 net0689[0] net0689[1] net0689[2] net0689[3] net0689[4] net0689[5]
+ net0689[6] net0689[7] net0689[8] net0689[9] net0689[10] net0689[11]
+ net0689[12] net0689[13] net0689[14] net0689[15] net0757[0] net0757[1]
+ net0757[2] net0757[3] net0744[0] net0744[1] net0744[2] net0744[3] net0744[4]
+ net0744[5] net0744[6] net0744[7] net0744[8] net0744[9] net0744[10]
+ net0744[11] net0744[12] net0744[13] net0744[14] net0744[15] net0799[0]
+ net0799[1] net0799[2] net0799[3] net0830 net0851 net0818[0] net0818[1]
+ net0818[2] net0818[3] net0847[0] net0847[1] net0847[2] net0847[3] net0349[0]
+ net0349[1] net0349[2] net0349[3] net0841[0] net0841[1] net0841[2] net0841[3]
+ net0735[0] net0735[1] net0735[2] net0735[3] net0746[0] net0746[1] net0746[2]
+ net0746[3] net0721 net0716[0] net0716[1] net0716[2] net0716[3] net0771
+ net0639 net0668 net0806 net0849[0] net0849[1] net0849[2] net0849[3] /
+ lmx_cm4x4
XI48 net0756[0] net0756[1] net0756[2] net0756[3] net0756[4] net0756[5]
+ net0756[6] net0756[7] net0756[8] net0756[9] net0756[10] net0756[11]
+ net0756[12] net0756[13] net0756[14] net0756[15] net0822[0] net0822[1]
+ net0822[2] net0822[3] net0805[0] net0805[1] net0805[2] net0805[3] net0805[4]
+ net0805[5] net0805[6] net0805[7] net0805[8] net0805[9] net0805[10]
+ net0805[11] net0805[12] net0805[13] net0805[14] net0805[15] net0691[0]
+ net0691[1] net0691[2] net0691[3] net0694 net0754 net0727[0] net0727[1]
+ net0727[2] net0727[3] net0749[0] net0749[1] net0749[2] net0749[3] net0635[0]
+ net0635[1] net0635[2] net0635[3] net0643[0] net0643[1] net0643[2] net0643[3]
+ net0711[0] net0711[1] net0711[2] net0711[3] net0748[0] net0748[1] net0748[2]
+ net0748[3] net0786 net0772[0] net0772[1] net0772[2] net0772[3] net0730
+ net0856 net0826 net0726 net0846[0] net0846[1] net0846[2] net0846[3] /
+ lmx_cm4x4
XI39 net0199[0] net0199[1] net0199[2] net0199[3] net0199[4] net0199[5]
+ net0199[6] net0199[7] net0199[8] net0199[9] net0199[10] net0199[11]
+ net0199[12] net0199[13] net0199[14] net0199[15] net0204[0] net0204[1]
+ net0204[2] net0204[3] net0347[0] net0347[1] net0347[2] net0347[3] net0347[4]
+ net0347[5] net0347[6] net0347[7] net0347[8] net0347[9] net0347[10]
+ net0347[11] net0347[12] net0347[13] net0347[14] net0347[15] net0194[0]
+ net0194[1] net0194[2] net0194[3] net0196 net0359 net0190[0] net0190[1]
+ net0190[2] net0190[3] net0191[0] net0191[1] net0191[2] net0191[3] net0192[0]
+ net0192[1] net0192[2] net0192[3] net0193[0] net0193[1] net0193[2] net0193[3]
+ net0206[0] net0206[1] net0206[2] net0206[3] net0201[0] net0201[1] net0201[2]
+ net0201[3] net0207 net0203[0] net0203[1] net0203[2] net0203[3] net0384
+ net0205 net0371 net0208 net0195[0] net0195[1] net0195[2] net0195[3] /
+ lmx_cm4x4
XI10 net0364[0] net0364[1] net0364[2] net0364[3] net0364[4] net0364[5]
+ net0364[6] net0364[7] net0364[8] net0364[9] net0364[10] net0364[11]
+ net0364[12] net0364[13] net0364[14] net0364[15] net0379[0] net0379[1]
+ net0379[2] net0379[3] net0215[0] net0215[1] net0215[2] net0215[3] net0215[4]
+ net0215[5] net0215[6] net0215[7] net0215[8] net0215[9] net0215[10]
+ net0215[11] net0215[12] net0215[13] net0215[14] net0215[15] net0213[0]
+ net0213[1] net0213[2] net0213[3] net113 net115 net0209[0] net0209[1]
+ net0209[2] net0209[3] net0210[0] net0210[1] net0210[2] net0210[3] net0211[0]
+ net0211[1] net0211[2] net0211[3] net0212[0] net0212[1] net0212[2] net0212[3]
+ net0352[0] net0352[1] net0352[2] net0352[3] net0395[0] net0395[1] net0395[2]
+ net0395[3] net114 net0398[0] net0398[1] net0398[2] net0398[3] net109 net110
+ net112 net0367 net0214[0] net0214[1] net0214[2] net0214[3] / lmx_cm4x4
XI52 net0430 net0432 net0439 net0438[0] net0438[1] net0438[2] net0438[3]
+ net0441 net0443 net0424[0] net0424[1] net0424[2] net0424[3] net0434 net0431
+ net0423 net0442 net0433 net0427 net0435 net0436 net0440 net0428 net0437[0]
+ net0437[1] net0437[2] net0425 net0429 net0426 / cache1_lio_64
XI36 net0240 net0357 net0237 net0236[0] net0236[1] net0236[2] net0236[3]
+ net0258 net0260 net0254[0] net0254[1] net0254[2] net0254[3] net0238 net0239
+ net0363 net0259 net0234 net0400 net0252 net0253 net0257 net0241 net0235[0]
+ net0235[1] net0235[2] net0368 net0365 net0356 / cache1_lio_64
XI40 net0377 net0255 net0385[0] net0385[1] net0385[2] net0385[3] net0249[0]
+ net0249[1] net0249[2] net0249[3] net0262 net0250 net0256 net0355 net0358
+ net0390 net0261 net0381 net0372[0] net0372[1] net0372[2] net0251[0]
+ net0251[1] net0251[2] / cache_rebuf
XI49 net0485[0] net0485[1] net0485[2] net0485[3] net0485[4] net0485[5]
+ net0485[6] net0485[7] net0481[0] net0481[1] net0489[0] net0489[1] net0489[2]
+ net0489[3] net0489[4] net0489[5] net0489[6] net0489[7] net0492[0] net0492[1]
+ net0483 net0484 net0487[0] net0487[1] net0487[2] net0487[3] net0480[0]
+ net0480[1] net0480[2] net0480[3] net0488[0] net0488[1] net0479[0] net0479[1]
+ net0494 net0491[0] net0491[1] net0491[2] net0491[3] net0490 net0493 net0486
+ net0495 net0482[0] net0482[1] net0482[2] net0482[3] / lmx_cm4x2
XI44 net0502[0] net0502[1] net0502[2] net0502[3] net0502[4] net0502[5]
+ net0502[6] net0502[7] net0498[0] net0498[1] net0506[0] net0506[1] net0506[2]
+ net0506[3] net0506[4] net0506[5] net0506[6] net0506[7] net0509[0] net0509[1]
+ net0500 net0501 net0504[0] net0504[1] net0504[2] net0504[3] net0497[0]
+ net0497[1] net0497[2] net0497[3] net0505[0] net0505[1] net0496[0] net0496[1]
+ net0511 net0508[0] net0508[1] net0508[2] net0508[3] net0507 net0510 net0503
+ net0512 net0499[0] net0499[1] net0499[2] net0499[3] / lmx_cm4x2
XI11 net0266[0] net0266[1] net0266[2] net0266[3] net0266[4] net0266[5]
+ net0266[6] net0266[7] net0374[0] net0374[1] net0268[0] net0268[1] net0268[2]
+ net0268[3] net0268[4] net0268[5] net0268[6] net0268[7] net0270[0] net0270[1]
+ net48 net50 net0271[0] net0271[1] net0271[2] net0271[3] net0272[0]
+ net0272[1] net0272[2] net0272[3] net0267[0] net0267[1] net0263[0] net0263[1]
+ net49 net0269[0] net0269[1] net0269[2] net0269[3] net46 net51 net47 net0273
+ net0265[0] net0265[1] net0265[2] net0265[3] / lmx_cm4x2
XI25 net0281[0] net0281[1] net0281[2] net0281[3] net0281[4] net0281[5]
+ net0281[6] net0281[7] net0286[0] net0286[1] net0282[0] net0282[1] net0282[2]
+ net0282[3] net0282[4] net0282[5] net0282[6] net0282[7] net0285[0] net0285[1]
+ net048 net050 net0289[0] net0289[1] net0289[2] net0289[3] net0284[0]
+ net0284[1] net0284[2] net0284[3] net0288[0] net0288[1] net0287[0] net0287[1]
+ net049 net0283[0] net0283[1] net0283[2] net0283[3] net046 net051 net047
+ net0290 net0280[0] net0280[1] net0280[2] net0280[3] / lmx_cm4x2
XI45 net0553[0] net0553[1] net0551 net0552[0] net0552[1] net0547 net0548
+ net0556[0] net0556[1] net0556[2] net0556[3] net0549[0] net0549[1] net0549[2]
+ net0549[3] net0555[0] net0555[1] net0554[0] net0554[1] net0560 net0559
+ net0558 net0550 net0557 net0561 / lio_pg8
XI24 net0301[0] net0301[1] net0297 net0300[0] net0300[1] net0122 net0124
+ net0304[0] net0304[1] net0304[2] net0304[3] net0299[0] net0299[1] net0299[2]
+ net0299[3] net0303[0] net0303[1] net0382[0] net0382[1] net0123 net0298
+ net0118 net0119 net0121 net0305 / lio_pg8
XI33 net0312 net0313 net061 net0314 net0315 net058 net063 net059 / lio_pg_rebuf
XI54 net0607 net0604 net0597 net0601 net0602 net0598[0] net0598[1] net0598[2]
+ net0598[3] net0600 net0606 net0609 net0599 net0608 net0603 net0605 net0610 /
+ lio_pg4
XI29 net0338 net0336 net0332 net0218 net0220 net0333[0] net0333[1] net0333[2]
+ net0333[3] net0335 net0337 net0219 net0334 net0216 net0221 net0217 net0339 /
+ lio_pg4
XI50 net0825[0] net0825[1] net0781 net0276[0] net0276[1] net0656[0] net0656[1]
+ net0656[2] net0656[3] net0697 net0275 net01080[0] net01080[1] net01080[2]
+ net01080[3] net0994[0] net0994[1] net0994[2] net0994[3] net0672[0]
+ net0672[1] net0733[0] net0733[1] net01084 net01099 net0274 net0842 net0674
+ net0838 net0850 net0665 net0817 net0796[0] net0796[1] net0796[2] net0803[0]
+ net0803[1] net0760[0] net0760[1] net0789[0] net0789[1] / cache2_lio_64
XI12 net0146[0] net0146[1] net0370 net0156[0] net0156[1] net0155[0] net0155[1]
+ net0155[2] net0155[3] net0159 net0160 net01095[0] net01095[1] net01095[2]
+ net01095[3] net0923[0] net0923[1] net0923[2] net0923[3] net0144[0]
+ net0144[1] net0145[0] net0145[1] net0575 net0576 net143 net0153 net0148
+ net140 net145 net141 net0161 net0361[0] net0361[1] net0361[2] net0394[0]
+ net0394[1] net0401[0] net0401[1] net0151[0] net0151[1] / cache2_lio_64
XI57 net0307[0] net0307[1] net0307[2] net0307[3] net0309 net0317[0] net0317[1]
+ net0317[2] net0317[3] net0316[0] net0316[1] net0316[2] net0316[3] net0319
+ net0321 net0673[0] net0673[1] net0673[2] net0673[3] net0758[0] net0758[1]
+ net0758[2] net0758[3] net0728[0] net0728[1] net0728[2] net0728[3] net0666[0]
+ net0666[1] net0666[2] net0666[3] net0775[0] net0775[1] net0775[2] net0775[3]
+ net0308[0] net0308[1] net0308[2] net0308[3] net0622 net0621 net0916 net01069
+ net0320 net0311 net0725 net0802 net0832 net0318 net0306 net0732[0]
+ net0732[1] net0732[2] net0310[0] net0310[1] net0310[2] net0310[3] net0713[0]
+ net0713[1] net0713[2] net0713[3] net0795[0] net0795[1] net0795[2] net0795[3]
+ / cache4_lio_64
XI38 net0185[0] net0185[1] net0185[2] net0185[3] net0169 net0179[0] net0179[1]
+ net0179[2] net0179[3] net0173[0] net0173[1] net0173[2] net0173[3] net0180
+ net0181 net0175[0] net0175[1] net0175[2] net0175[3] net0176[0] net0176[1]
+ net0176[2] net0176[3] net0177[0] net0177[1] net0177[2] net0177[3] net0178[0]
+ net0178[1] net0178[2] net0178[3] net0187[0] net0187[1] net0187[2] net0187[3]
+ net0183[0] net0183[1] net0183[2] net0183[3] net0777 net0174[1] net0174[2]
+ net0174[3] net0188 net0171 net0168 net0184 net0186 net0182 net0189
+ net0172[0] net0172[1] net0172[2] net0346[0] net0346[1] net0346[2] net0346[3]
+ net0167[0] net0167[1] net0167[2] net0167[3] net0166[0] net0166[1] net0166[2]
+ net0166[3] / cache4_lio_64
XI69 net01072 net0907[0] net0907[1] net0907[2] net0907[3] net01106 net01002
+ net01098 net0991 net01105 net01094 net01066[0] net01066[1] net01066[2] /
+ cache1_lio_edge
XI62 net0712 net0879[0] net0879[1] net0879[2] net0879[3] net0922 net0862
+ net0704 net0724 net0947 net0941 net0899[0] net0899[1] net0899[2] /
+ cache1_lio_edge
XI70 net01052 net0996[0] net0996[1] net0996[2] net0996[3] net0708 net0702
+ net01064 net0968 net01048 net0863 net01096[0] net01096[1] net01096[2] /
+ cache2_lio_edge
XI64 net0893 net0859[0] net0859[1] net0859[2] net0859[3] net0974 net0874
+ net0664 net0948 net0759 net0671 net0669[0] net0669[1] net0669[2] /
+ cache2_lio_edge
XI71 net01108 net01078[0] net01078[1] net01078[2] net01078[3] net01104
+ net01107 net01076 net0927 net01034 net0731 net0834[0] net0834[1] net0834[2]
+ / cache4_lio_edge
XI65 net0677 net0682[0] net0682[1] net0682[2] net0682[3] net0684 net0921
+ net0676 net0679 net0686 net0683 net0681[0] net0681[1] net0681[2] /
+ cache4_lio_edge
XI67 net01060 net01070 net01074 net01018 net0934 net0924 / lio_pg_edge
XI60 net0722 net0614 net0698 net0612 net0800 net0611 / lio_pg_edge
.ENDS

.SUBCKT floorplan_llio
*.PININFO
XI56 net138 net160 net146 net165 net156 net145 net148 net139[0] net139[1]
+ net139[2] net139[3] net0188 net173 net163 net167[0] net167[1] net167[2]
+ net167[3] net0135 net153 net141 net133 net140 net136 net135 net164[0]
+ net164[1] net164[2] net164[3] net164[4] net164[5] net164[6] net164[7]
+ net164[8] net164[9] net164[10] net164[11] net172[0] net172[1] net172[2]
+ net143 net144 net151 net149 net142 net150 net169 net155 net158[0] net158[1]
+ net158[2] net158[3] net154 net137 net152[0] net152[1] net152[2] net134[0]
+ net134[1] net134[2] net168[0] net168[1] net168[2] net168[3] net175[0]
+ net175[1] net175[2] net175[3] net174[0] net174[1] net174[2] net174[3]
+ net159[0] net159[1] net159[2] net159[3] net166[0] net166[1] net166[2]
+ net166[3] net162[0] net162[1] net162[2] net162[3] net176 net170 net171
+ net0181 net147 net157 / sactl
XI23 net2 net047 net31 net28 net11[0] net11[1] net11[2] net11[3] net01 net34
+ net20 net1 net14 net21 net26[0] net26[1] net26[2] net26[3] net8[0] net8[1]
+ net8[2] net8[3] net27[0] net27[1] net27[2] net27[3] net10[0] net10[1]
+ net10[2] net10[3] net17 net4[0] net4[1] net4[2] net4[3] net4[4] net4[5]
+ net4[6] net4[7] net4[8] net4[9] net4[10] net4[11] net5[0] net5[1] net5[2]
+ net5[3] net23[0] net23[1] net23[2] net13 net3 net16 net29 net9 net25[0]
+ net25[1] net25[2] net25[3] net15 net36[0] net36[1] net36[2] net36[3] net19
+ net24[0] net24[1] net24[2] net30[0] net30[1] net30[2] net30[3] net35[0]
+ net35[1] net35[2] net35[3] net32[0] net32[1] net32[2] net32[3] net18[0]
+ net18[1] net18[2] net18[3] net22[0] net22[1] net22[2] net22[3] net12 net045
+ net7 net33 / zctl
XI52 net38 net085 net67 net64 net47[0] net47[1] net47[2] net47[3] net038 net70
+ net56 net37 net50 net57 net62[0] net62[1] net62[2] net62[3] net44[0]
+ net44[1] net44[2] net44[3] net63[0] net63[1] net63[2] net63[3] net46[0]
+ net46[1] net46[2] net46[3] net53 net40[0] net40[1] net40[2] net40[3]
+ net40[4] net40[5] net40[6] net40[7] net40[8] net40[9] net40[10] net40[11]
+ net41[0] net41[1] net41[2] net41[3] net59[0] net59[1] net59[2] net49 net39
+ net52 net65 net45 net61[0] net61[1] net61[2] net61[3] net51 net72[0]
+ net72[1] net72[2] net72[3] net55 net60[0] net60[1] net60[2] net66[0]
+ net66[1] net66[2] net66[3] net71[0] net71[1] net71[2] net71[3] net68[0]
+ net68[1] net68[2] net68[3] net54[0] net54[1] net54[2] net54[3] net58[0]
+ net58[1] net58[2] net58[3] net48 net082 net43 net69 / zctl
XI53 net95 net90 net0123 net100 net93 net77[0] net77[1] net77[2] net77[3]
+ net76 net74 net97 net86 net91 net88[0] net88[1] net88[2] net88[3] net88[4]
+ net88[5] net88[6] net88[7] net88[8] net88[9] net88[10] net88[11] net82[0]
+ net82[1] net82[2] net78 net94 net79 net75 net98 net81 net85[0] net85[1]
+ net85[2] net85[3] net80 net84 net96[0] net96[1] net96[2] net99[0] net99[1]
+ net99[2] net99[3] net102[0] net102[1] net102[2] net102[3] net101[0]
+ net101[1] net101[2] net101[3] net83[0] net83[1] net83[2] net83[3] net87[0]
+ net87[1] net87[2] net87[3] net73 net89 net92 / sactl_pg
XI54 net120 net124 net0154 net130 net122 net107[0] net107[1] net107[2]
+ net107[3] net106 net104 net127 net116 net123 net118[0] net118[1] net118[2]
+ net118[3] net118[4] net118[5] net118[6] net118[7] net118[8] net118[9]
+ net118[10] net118[11] net112[0] net112[1] net112[2] net108 net109[0]
+ net109[1] net109[2] net109[3] net125 net105 net128 net111 net115[0]
+ net115[1] net115[2] net115[3] net110 net114 net126[0] net126[1] net126[2]
+ net129[0] net129[1] net129[2] net129[3] net132[0] net132[1] net132[2]
+ net132[3] net131[0] net131[1] net131[2] net131[3] net113[0] net113[1]
+ net113[2] net113[3] net117[0] net117[1] net117[2] net117[3] net103 net119
+ net121 / sactl_sb
XI24  / floorplan_lio
XI55  / floorplan_lio
.ENDS

.SUBCKT floorplan_spram
*.PININFO
XI33 net0218 net0206 net0209 net0195[0] net0195[1] net0195[2] net0195[3]
+ net0234 net0232 net0179 net0202 net0199[0] net0199[1] net0199[2] net0199[3]
+ net0199[4] net0199[5] net0199[6] net0199[7] net0199[8] net0199[9]
+ net0199[10] net0199[11] net0204[0] net0204[1] net0204[2] net0182 net0198
+ net0211 net0220[0] net0220[1] net0220[2] net0220[3] net0160[0] net0160[1]
+ net0160[2] net0156 net0235 / red_gctl
XI2  / floorplan_gio_red
XI1  / floorplan_gio_red
XI39 net066[0] net066[1] net066[2] net066[3] net066[4] net066[5] net066[6]
+ net066[7] net066[8] net066[9] net066[10] net066[11] net066[12] net066[13]
+ net0423 net068 net0468 net0405 net0492 net0479[0] net0479[1] net0479[2]
+ net0479[3] net054 net0444 net0450 net0476 net0435 net061[0] net061[1]
+ net061[2] net061[3] net031 net067 net0394 net064[0] net064[1] net064[2]
+ net064[3] net053 net0426 net0487 net062 net0456 net0407 net052 net057
+ net0467[0] net0467[1] net0467[2] net0467[3] net0467[4] net0467[5] net0467[6]
+ net0467[7] net0467[8] net0467[9] net0467[10] net0467[11] net0445 net0421[0]
+ net0421[1] net0421[2] net0478[0] net0478[1] net0478[2] net0429 net0443
+ net0463 net0496 net069 net0430 net065 net0480 net0458[0] net0458[1]
+ net0458[2] net0458[3] net0458[4] net0458[5] net0458[6] net0458[7] net0458[8]
+ net0458[9] net0458[10] net0458[11] net0458[12] net0458[13] net0505 net0460
+ net0401 net0412 net0470 net0409 net0393 net0387 net0410 net059 net0402
+ net0382 net0453 net0440[0] net0440[1] net0440[2] net0440[3] net058 net070
+ net0454[0] net0454[1] net0454[2] net0497[0] net0497[1] net0497[2] net0488
+ net056 / gctl_cache_cm8
XI37 net0124[0] net0124[1] net0124[2] net0124[3] net0124[4] net0124[5]
+ net0124[6] net0124[7] net0124[8] net0124[9] net0124[10] net0124[11]
+ net0124[12] net0124[13] net0494 net0126 net0404 net083 net0451 net0105[0]
+ net0105[1] net0105[2] net0105[3] net0490 net0465 net0395 net0503 net0130
+ net0119[0] net0119[1] net0119[2] net0119[3] net0471 net0125 net0381
+ net0122[0] net0122[1] net0122[2] net0122[3] net0111 net0449 net0477 net0120
+ net0108 net0486 net0110 net0115 net0113[0] net0113[1] net0113[2] net0113[3]
+ net0113[4] net0113[5] net0113[6] net0113[7] net0113[8] net0113[9]
+ net0113[10] net0113[11] net0442 net0118[0] net0118[1] net0118[2] net0133[0]
+ net0133[1] net0133[2] net0420 net081 net0427 net0461 net0504 net0502 net0123
+ net0498 net0425[0] net0425[1] net0425[2] net0425[3] net0425[4] net0425[5]
+ net0425[6] net0425[7] net0425[8] net0425[9] net0425[10] net0425[11]
+ net0425[12] net0425[13] net0457 net0131 net0129 net0413 net0104 net0414
+ net0132 net0500 net0396 net0117 net0406 net0464 net0107 net0473[0]
+ net0473[1] net0473[2] net0473[3] net0116 net0128 net0106[0] net0106[1]
+ net0106[2] net0491[0] net0491[1] net0491[2] net0493 net0114 /
+ gctl_cache_cm4_bk
XI12 net049[0] net049[1] net049[2] net049[3] net049[4] net049[5] net049[6]
+ net049[7] net049[8] net049[9] net049[10] net049[11] net049[12] net049[13]
+ net0217 net051 net0216 net0212 net0127 net029[0] net029[1] net029[2]
+ net029[3] net037 net0226 net0197 net0146 net060 net044[0] net044[1]
+ net044[2] net044[3] net0224 net050 net04 net047[0] net047[1] net047[2]
+ net047[3] net036 net022 net021 net045 net033 net014 net035 net040 net038[0]
+ net038[1] net038[2] net038[3] net038[4] net038[5] net038[6] net038[7]
+ net038[8] net038[9] net038[10] net038[11] net023 net043[0] net043[1]
+ net043[2] net063[0] net063[1] net063[2] net020 net03 net046 net034 net0121
+ net0112 net048 net017 net018[0] net018[1] net018[2] net018[3] net018[4]
+ net018[5] net018[6] net018[7] net018[8] net018[9] net018[10] net018[11]
+ net018[12] net018[13] net0184 net0161 net055 net015 net028 net01 net0164
+ net025 net024 net042 net026 net027 net032 net016[0] net016[1] net016[2]
+ net016[3] net041 net0109 net030[0] net030[1] net030[2] net019[0] net019[1]
+ net019[2] net02 net039 / gctl_cache
XI38 net0240[0] net0240[1] net0240[2] net0240[3] net0240[4] net0240[5]
+ net0240[6] net0240[7] net0240[8] net0240[9] net0240[10] net0240[11]
+ net0240[12] net0240[13] net0446 net0242 net0433 net0431 net0193 net0221[0]
+ net0221[1] net0221[2] net0221[3] net0228 net0201 net0397 net0192 net0246
+ net0438[0] net0438[1] net0438[2] net0438[3] net0501 net0241 net0380
+ net0238[0] net0238[1] net0238[2] net0238[3] net0437 net0439 net0213 net0236
+ net0386 net0441 net0378 net0231 net0229[0] net0229[1] net0229[2] net0229[3]
+ net0229[4] net0229[5] net0229[6] net0229[7] net0229[8] net0229[9]
+ net0229[10] net0229[11] net0472 net0398[0] net0398[1] net0398[2] net0249[0]
+ net0249[1] net0249[2] net0436 net0403 net0237 net0469 net0243 net0499
+ net0239 net0475 net0210[0] net0210[1] net0210[2] net0210[3] net0210[4]
+ net0210[5] net0210[6] net0210[7] net0210[8] net0210[9] net0210[10]
+ net0210[11] net0210[12] net0210[13] net0462 net0247 net0245 net0207 net0377
+ net0483 net0248 net0481 net0422 net0233 net0484 net0219 net0428 net0459[0]
+ net0459[1] net0459[2] net0459[3] net0424 net0244 net0489[0] net0489[1]
+ net0489[2] net0379[0] net0379[1] net0379[2] net0495 net0230 /
+ gctl_cache_cm8_bk
XI34 net0215 net0180 net0178 net0187[0] net0187[1] net0187[2] net0187[3]
+ net0214 net0174 net0185 net0203 net0200[0] net0200[1] net0200[2] net0200[3]
+ net0200[4] net0200[5] net0200[6] net0200[7] net0200[8] net0200[9]
+ net0200[10] net0200[11] net0194[0] net0194[1] net0194[2] net0191 net0222
+ net0196 net0223[0] net0223[1] net0223[2] net0223[3] net0170[0] net0170[1]
+ net0170[2] net0190 net0225 / gctl_gcsmx
XI26  / floorplan_sbank
XI25  / floorplan_sbank
XI29  / floorplan_sbank
XI32 net089[0] net089[1] net089[2] net089[3] net089[4] net089[5] net089[6]
+ net089[7] net089[8] net089[9] net089[10] net089[11] net089[12] net089[13]
+ net0227 net082 net095 net093 net0173 net0205 net090 net085 net098 net0102
+ net078 net080[0] net080[1] net080[2] net077 net097 net092 net096 net094
+ net091 net088[0] net088[1] net088[2] net088[3] net088[4] net088[5] net088[6]
+ net088[7] net088[8] net088[9] net088[10] net088[11] net088[12] net088[13]
+ net0208 net099 net084 net071 net076 net086 net0101 net0100 net075 net074
+ net073 net072 net0103 net087 net079[0] net079[1] net079[2] / gctlpg
XI36 net0350[0] net0350[1] net0350[2] net0350[3] net0350[4] net0350[5]
+ net0350[6] net0350[7] net0350[8] net0350[9] net0350[10] net0350[11]
+ net0350[12] net0350[13] net0314 net0352 net0310 net0309 net0303 net0331[0]
+ net0331[1] net0331[2] net0331[3] net0338 net0311 net0313 net0302 net0356
+ net0345[0] net0345[1] net0345[2] net0345[3] net0315 net0351 net0308
+ net0348[0] net0348[1] net0348[2] net0348[3] net0337 net0324 net0323 net0346
+ net0334 net0316 net0336 net0341 net0339[0] net0339[1] net0339[2] net0339[3]
+ net0339[4] net0339[5] net0339[6] net0339[7] net0339[8] net0339[9]
+ net0339[10] net0339[11] net0325 net0344[0] net0344[1] net0344[2] net0359[0]
+ net0359[1] net0359[2] net0322 net0307 net0347 net0335 net0353 net0304
+ net0349 net0319 net0320[0] net0320[1] net0320[2] net0320[3] net0320[4]
+ net0320[5] net0320[6] net0320[7] net0320[8] net0320[9] net0320[10]
+ net0320[11] net0320[12] net0320[13] net0312 net0357 net0355 net0317 net0330
+ net0305 net0358 net0327 net0326 net0343 net0328 net0329 net0333 net0318[0]
+ net0318[1] net0318[2] net0318[3] net0342 net0354 net0332[0] net0332[1]
+ net0332[2] net0321[0] net0321[1] net0321[2] net0306 net0340 / gctl_cache_cm4
XI35 net0142 net0157 net0145 net0171[0] net0171[1] net0171[2] net0171[3]
+ net0150 net0149 net0154 net0153 net0151[0] net0151[1] net0151[2] net0151[3]
+ net0151[4] net0151[5] net0151[6] net0151[7] net0151[8] net0151[9]
+ net0151[10] net0151[11] net0158[0] net0158[1] net0158[2] net0155 net0143
+ net0147 net0165[0] net0165[1] net0165[2] net0165[3] net0148[0] net0148[1]
+ net0148[2] net0168 net0152 / gctl_grdmx
XI30  / floorplan_gpg
XI31  / floorplan_gpg
XI27  / floorplan_llio
XI28  / floorplan_llio
.ENDS

.subckt spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE BADIO[0] TBWM[0] BWM[0]
+ TD[0] D[0] Q[0] BPU SPU VNW VSS VDDA PWR
*.pininfo BADIO[0]:B TBWM[0]:B BWM[0]:B TD[0]:B D[0]:B Q[0]:B BPU:B SPU:B
*.pininfo VNW:B VSS:B VDDA:B PWR:B
XX00 BADIO[0] BPU BWM[0] D[0] PWR Q[0] SPU TBWM[0] TD[0] VDDA VNW VSS
+ giopg4 m=1
.ends spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE

.subckt spram_4096x16m16b1pm2re1M16_RA_GPGARY BADIO[0] TBWM[0] BWM[0] TD[0]
+ D[0] Q[0] BPU SPU VNW VSS VDDA PWR BADIO[1] TBWM[1] BWM[1] TD[1] D[1] Q[1]
+ BADIO[2] TBWM[2] BWM[2] TD[2] D[2] Q[2] BADIO[3] TBWM[3] BWM[3] TD[3] D[3]
+ Q[3] BADIO[4] TBWM[4] BWM[4] TD[4] D[4] Q[4] BADIO[5] TBWM[5] BWM[5] TD[5]
+ D[5] Q[5] BADIO[6] TBWM[6] BWM[6] TD[6] D[6] Q[6] BADIO[7] TBWM[7] BWM[7]
+ TD[7] D[7] Q[7]
*.pininfo BADIO[0]:B TBWM[0]:B BWM[0]:B TD[0]:B D[0]:B Q[0]:B BPU:B SPU:B
*.pininfo VNW:B VSS:B VDDA:B PWR:B BADIO[1]:B TBWM[1]:B BWM[1]:B TD[1]:B
*.pininfo D[1]:B Q[1]:B BADIO[2]:B TBWM[2]:B BWM[2]:B TD[2]:B D[2]:B Q[2]:B
*.pininfo BADIO[3]:B TBWM[3]:B BWM[3]:B TD[3]:B D[3]:B Q[3]:B BADIO[4]:B
*.pininfo TBWM[4]:B BWM[4]:B TD[4]:B D[4]:B Q[4]:B BADIO[5]:B TBWM[5]:B
*.pininfo BWM[5]:B TD[5]:B D[5]:B Q[5]:B BADIO[6]:B TBWM[6]:B BWM[6]:B
*.pininfo TD[6]:B D[6]:B Q[6]:B BADIO[7]:B TBWM[7]:B BWM[7]:B TD[7]:B D[7]:B
*.pininfo Q[7]:B
XX00 BADIO[0] TBWM[0] BWM[0] TD[0] D[0] Q[0] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
XX01 BADIO[1] TBWM[1] BWM[1] TD[1] D[1] Q[1] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
XX02 BADIO[2] TBWM[2] BWM[2] TD[2] D[2] Q[2] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
XX03 BADIO[3] TBWM[3] BWM[3] TD[3] D[3] Q[3] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
XX04 BADIO[4] TBWM[4] BWM[4] TD[4] D[4] Q[4] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
XX05 BADIO[5] TBWM[5] BWM[5] TD[5] D[5] Q[5] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
XX06 BADIO[6] TBWM[6] BWM[6] TD[6] D[6] Q[6] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
XX07 BADIO[7] TBWM[7] BWM[7] TD[7] D[7] Q[7] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_RA_GPGARY_SLICE m=1
.ends spram_4096x16m16b1pm2re1M16_RA_GPGARY

.subckt spram_4096x16m16b1pm2re1M16_RA VSS VDDA PWR BPU SPU VNW BADIO[0]
+ BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7] TBWM[0]
+ TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6] TBWM[7] BWM[0] BWM[1]
+ BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7] TD[0] TD[1] TD[2] TD[3] TD[4]
+ TD[5] TD[6] TD[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7]
*.pininfo VSS:B VDDA:B PWR:B BPU:B SPU:B VNW:B BADIO[0]:B BADIO[1]:B
*.pininfo BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B BADIO[6]:B BADIO[7]:B
*.pininfo TBWM[0]:B TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B TBWM[5]:B
*.pininfo TBWM[6]:B TBWM[7]:B BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B
*.pininfo BWM[5]:B BWM[6]:B BWM[7]:B TD[0]:B TD[1]:B TD[2]:B TD[3]:B TD[4]:B
*.pininfo TD[5]:B TD[6]:B TD[7]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B D[5]:B
*.pininfo D[6]:B D[7]:B Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B Q[6]:B
*.pininfo Q[7]:B
XXspram_4096x16m16b1pm2re1M16_RA_GPGARY_0_R BADIO[0] TBWM[0] BWM[0] TD[0]
+ D[0] Q[0] BPU SPU VNW VSS VDDA PWR BADIO[1] TBWM[1] BWM[1] TD[1] D[1] Q[1]
+ BADIO[2] TBWM[2] BWM[2] TD[2] D[2] Q[2] BADIO[3] TBWM[3] BWM[3] TD[3] D[3]
+ Q[3] BADIO[4] TBWM[4] BWM[4] TD[4] D[4] Q[4] BADIO[5] TBWM[5] BWM[5] TD[5]
+ D[5] Q[5] BADIO[6] TBWM[6] BWM[6] TD[6] D[6] Q[6] BADIO[7] TBWM[7] BWM[7]
+ TD[7] D[7] Q[7] spram_4096x16m16b1pm2re1M16_RA_GPGARY m=1
.ends spram_4096x16m16b1pm2re1M16_RA

.subckt spram_4096x16m16b1pm2re1M16_R PWR VDDA VSS BPU SPU VNW BADIO[0]
+ BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0]
+ BWM[1] BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4]
+ D[5] D[6] D[7] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1]
+ TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3]
+ TD[4] TD[5] TD[6] TD[7]
*.pininfo PWR:B VDDA:B VSS:B BPU:B SPU:B VNW:B BADIO[0]:B BADIO[1]:B
*.pininfo BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B BADIO[6]:B BADIO[7]:B
*.pininfo BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B BWM[5]:B BWM[6]:B
*.pininfo BWM[7]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B D[5]:B D[6]:B D[7]:B
*.pininfo Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B Q[6]:B Q[7]:B TBWM[0]:B
*.pininfo TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B TBWM[5]:B TBWM[6]:B
*.pininfo TBWM[7]:B TD[0]:B TD[1]:B TD[2]:B TD[3]:B TD[4]:B TD[5]:B TD[6]:B
*.pininfo TD[7]:B
XXspram_4096x16m16b1pm2re1M16_RA_0 VSS VDDA PWR BPU SPU VNW BADIO[0] BADIO[1]
+ BADIO[2] BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7] TBWM[0] TBWM[1]
+ TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6] TBWM[7] BWM[0] BWM[1] BWM[2] BWM[3]
+ BWM[4] BWM[5] BWM[6] BWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7]
+ D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6]
+ Q[7] spram_4096x16m16b1pm2re1M16_RA m=1
.ends spram_4096x16m16b1pm2re1M16_R

.subckt spram_4096x16m16b1pm2re1GP_GR BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] PWR VDDA
+ VSS BPUC SPUC VNW
*.pininfo BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B
*.pininfo BADIO[6]:B BADIO[7]:B BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B
*.pininfo BWM[5]:B BWM[6]:B BWM[7]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B
*.pininfo D[5]:B D[6]:B D[7]:B Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B
*.pininfo Q[6]:B Q[7]:B TBWM[0]:B TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B
*.pininfo TBWM[5]:B TBWM[6]:B TBWM[7]:B TD[0]:B TD[1]:B TD[2]:B TD[3]:B
*.pininfo TD[4]:B TD[5]:B TD[6]:B TD[7]:B PWR:B VDDA:B VSS:B BPUC:B SPUC:B
*.pininfo VNW:B
XXGP_GR PWR VDDA VSS BPUC SPUC VNW BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7]
+ spram_4096x16m16b1pm2re1M16_R m=1
.ends spram_4096x16m16b1pm2re1GP_GR

.subckt spram_4096x16m16b1pm2re1GP_GPG AWT LVTEST VSB400 VSB300 VSB200 VSB100
+ VSS RA WM[0] WM[1] WM[2] RM[0] RM[1] RM[2] CACHE_MISS BISTE TCLK CLK TWE WE
+ TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10] TA[11]
+ A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] TCE CE SD HN
+ SL SZ BPUI SPUI BPUC SPUC VNW VDDA PWR
*.pininfo AWT:B LVTEST:B VSB400:B VSB300:B VSB200:B VSB100:B VSS:B RA:B
*.pininfo WM[0]:B WM[1]:B WM[2]:B RM[0]:B RM[1]:B RM[2]:B CACHE_MISS:B
*.pininfo BISTE:B TCLK:B CLK:B TWE:B WE:B TA[0]:B TA[1]:B TA[2]:B TA[3]:B
*.pininfo TA[4]:B TA[5]:B TA[6]:B TA[7]:B TA[8]:B TA[9]:B TA[10]:B TA[11]:B
*.pininfo A[0]:B A[1]:B A[2]:B A[3]:B A[4]:B A[5]:B A[6]:B A[7]:B A[8]:B
*.pininfo A[9]:B A[10]:B A[11]:B TCE:B CE:B SD:B HN:B SL:B SZ:B BPUI:B SPUI:B
*.pininfo BPUC:B SPUC:B VNW:B VDDA:B PWR:B
XXGP_GPG A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] VSS
+ VSS AWT BISTE BPUC BPUI VSS CACHE_MISS CE CLK HN PWR RA RM[0] RM[1] RM[2]
+ VSS SD SL SPUC SPUI SZ TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7]
+ TA[8] TA[9] TA[10] TA[11] VSS VSS VSS TCE TCLK LVTEST VSS TWE VDDA VNW
+ VSB100 VSB200 VSB300 VSB400 VSS WE WM[0] WM[1] WM[2] gctlpg m=1
.ends spram_4096x16m16b1pm2re1GP_GPG

.subckt spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE BADIO[0] TBWM[0] BWM[0]
+ TD[0] D[0] Q[0] BPU SPU VNW VSS VDDA PWR
*.pininfo BADIO[0]:B TBWM[0]:B BWM[0]:B TD[0]:B D[0]:B Q[0]:B BPU:B SPU:B
*.pininfo VNW:B VSS:B VDDA:B PWR:B
XX00 BADIO[0] BPU BWM[0] D[0] PWR Q[0] SPU TBWM[0] TD[0] VDDA VNW VSS
+ giopg4 m=1
.ends spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE

.subckt spram_4096x16m16b1pm2re1M16_LA_GPGARY BADIO[0] TBWM[0] BWM[0] TD[0]
+ D[0] Q[0] BPU SPU VNW VSS VDDA PWR BADIO[1] TBWM[1] BWM[1] TD[1] D[1] Q[1]
+ BADIO[2] TBWM[2] BWM[2] TD[2] D[2] Q[2] BADIO[3] TBWM[3] BWM[3] TD[3] D[3]
+ Q[3] BADIO[4] TBWM[4] BWM[4] TD[4] D[4] Q[4] BADIO[5] TBWM[5] BWM[5] TD[5]
+ D[5] Q[5] BADIO[6] TBWM[6] BWM[6] TD[6] D[6] Q[6] BADIO[7] TBWM[7] BWM[7]
+ TD[7] D[7] Q[7]
*.pininfo BADIO[0]:B TBWM[0]:B BWM[0]:B TD[0]:B D[0]:B Q[0]:B BPU:B SPU:B
*.pininfo VNW:B VSS:B VDDA:B PWR:B BADIO[1]:B TBWM[1]:B BWM[1]:B TD[1]:B
*.pininfo D[1]:B Q[1]:B BADIO[2]:B TBWM[2]:B BWM[2]:B TD[2]:B D[2]:B Q[2]:B
*.pininfo BADIO[3]:B TBWM[3]:B BWM[3]:B TD[3]:B D[3]:B Q[3]:B BADIO[4]:B
*.pininfo TBWM[4]:B BWM[4]:B TD[4]:B D[4]:B Q[4]:B BADIO[5]:B TBWM[5]:B
*.pininfo BWM[5]:B TD[5]:B D[5]:B Q[5]:B BADIO[6]:B TBWM[6]:B BWM[6]:B
*.pininfo TD[6]:B D[6]:B Q[6]:B BADIO[7]:B TBWM[7]:B BWM[7]:B TD[7]:B D[7]:B
*.pininfo Q[7]:B
XX00 BADIO[0] TBWM[0] BWM[0] TD[0] D[0] Q[0] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
XX01 BADIO[1] TBWM[1] BWM[1] TD[1] D[1] Q[1] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
XX02 BADIO[2] TBWM[2] BWM[2] TD[2] D[2] Q[2] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
XX03 BADIO[3] TBWM[3] BWM[3] TD[3] D[3] Q[3] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
XX04 BADIO[4] TBWM[4] BWM[4] TD[4] D[4] Q[4] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
XX05 BADIO[5] TBWM[5] BWM[5] TD[5] D[5] Q[5] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
XX06 BADIO[6] TBWM[6] BWM[6] TD[6] D[6] Q[6] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
XX07 BADIO[7] TBWM[7] BWM[7] TD[7] D[7] Q[7] BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPGARY_SLICE m=1
.ends spram_4096x16m16b1pm2re1M16_LA_GPGARY

.subckt spram_4096x16m16b1pm2re1M16_LA_RE_SLICE BADIO TBWM BWM TD D Q BPU SPU
+ VNW VSS VDDA PWR
*.pininfo BADIO:B TBWM:B BWM:B TD:B D:B Q:B BPU:B SPU:B VNW:B VSS:B VDDA:B
*.pininfo PWR:B
XX00 BADIO BPU BWM D PWR Q SPU TBWM TD VDDA VNW VSS giopg4 m=1
.ends spram_4096x16m16b1pm2re1M16_LA_RE_SLICE

.subckt spram_4096x16m16b1pm2re1M16_LA_GPG_RED VSS Q_RED BPU SPU VNW VDDA PWR
*.pininfo VSS:B Q_RED:B BPU:B SPU:B VNW:B VDDA:B PWR:B
XX00 VSS VSS VSS VSS VSS Q_RED BPU SPU VNW VSS VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_RE_SLICE m=1
.ends spram_4096x16m16b1pm2re1M16_LA_GPG_RED

.subckt spram_4096x16m16b1pm2re1M16_LA VSS VDDA PWR BPU SPU VNW BADIO[0]
+ BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7] TBWM[0]
+ TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6] TBWM[7] BWM[0] BWM[1]
+ BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7] TD[0] TD[1] TD[2] TD[3] TD[4]
+ TD[5] TD[6] TD[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] Q_RED
*.pininfo VSS:B VDDA:B PWR:B BPU:B SPU:B VNW:B BADIO[0]:B BADIO[1]:B
*.pininfo BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B BADIO[6]:B BADIO[7]:B
*.pininfo TBWM[0]:B TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B TBWM[5]:B
*.pininfo TBWM[6]:B TBWM[7]:B BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B
*.pininfo BWM[5]:B BWM[6]:B BWM[7]:B TD[0]:B TD[1]:B TD[2]:B TD[3]:B TD[4]:B
*.pininfo TD[5]:B TD[6]:B TD[7]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B D[5]:B
*.pininfo D[6]:B D[7]:B Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B Q[6]:B
*.pininfo Q[7]:B Q_RED:B
XXspram_4096x16m16b1pm2re1M16_LA_GPGARY_0_R BADIO[0] TBWM[0] BWM[0] TD[0]
+ D[0] Q[0] BPU SPU VNW VSS VDDA PWR BADIO[1] TBWM[1] BWM[1] TD[1] D[1] Q[1]
+ BADIO[2] TBWM[2] BWM[2] TD[2] D[2] Q[2] BADIO[3] TBWM[3] BWM[3] TD[3] D[3]
+ Q[3] BADIO[4] TBWM[4] BWM[4] TD[4] D[4] Q[4] BADIO[5] TBWM[5] BWM[5] TD[5]
+ D[5] Q[5] BADIO[6] TBWM[6] BWM[6] TD[6] D[6] Q[6] BADIO[7] TBWM[7] BWM[7]
+ TD[7] D[7] Q[7] spram_4096x16m16b1pm2re1M16_LA_GPGARY m=1
XXspram_4096x16m16b1pm2re1M16_LA_GPG_RED_0 VSS Q_RED BPU SPU VNW VDDA PWR
+ spram_4096x16m16b1pm2re1M16_LA_GPG_RED m=1
.ends spram_4096x16m16b1pm2re1M16_LA

.subckt spram_4096x16m16b1pm2re1M16_L PWR VDDA VSS BPU SPU VNW BADIO[0]
+ BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0]
+ BWM[1] BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4]
+ D[5] D[6] D[7] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1]
+ TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3]
+ TD[4] TD[5] TD[6] TD[7] Q_RED
*.pininfo PWR:B VDDA:B VSS:B BPU:B SPU:B VNW:B BADIO[0]:B BADIO[1]:B
*.pininfo BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B BADIO[6]:B BADIO[7]:B
*.pininfo BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B BWM[5]:B BWM[6]:B
*.pininfo BWM[7]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B D[5]:B D[6]:B D[7]:B
*.pininfo Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B Q[6]:B Q[7]:B TBWM[0]:B
*.pininfo TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B TBWM[5]:B TBWM[6]:B
*.pininfo TBWM[7]:B TD[0]:B TD[1]:B TD[2]:B TD[3]:B TD[4]:B TD[5]:B TD[6]:B
*.pininfo TD[7]:B Q_RED:B
XXspram_4096x16m16b1pm2re1M16_LA_0 VSS VDDA PWR BPU SPU VNW BADIO[0] BADIO[1]
+ BADIO[2] BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7] TBWM[0] TBWM[1]
+ TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6] TBWM[7] BWM[0] BWM[1] BWM[2] BWM[3]
+ BWM[4] BWM[5] BWM[6] BWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7]
+ D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6]
+ Q[7] Q_RED spram_4096x16m16b1pm2re1M16_LA m=1
.ends spram_4096x16m16b1pm2re1M16_L

.subckt spram_4096x16m16b1pm2re1GP_GL BPUC SPUC VNW VSS VDDA PWR BADIO[8]
+ BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13] BADIO[14] BADIO[15] BWM[8]
+ BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[8] D[9] D[10]
+ D[11] D[12] D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15]
+ TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13] TBWM[14] TBWM[15] TD[8]
+ TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] Q_RED
*.pininfo BPUC:B SPUC:B VNW:B VSS:B VDDA:B PWR:B BADIO[8]:B BADIO[9]:B
*.pininfo BADIO[10]:B BADIO[11]:B BADIO[12]:B BADIO[13]:B BADIO[14]:B
*.pininfo BADIO[15]:B BWM[8]:B BWM[9]:B BWM[10]:B BWM[11]:B BWM[12]:B
*.pininfo BWM[13]:B BWM[14]:B BWM[15]:B D[8]:B D[9]:B D[10]:B D[11]:B D[12]:B
*.pininfo D[13]:B D[14]:B D[15]:B Q[8]:B Q[9]:B Q[10]:B Q[11]:B Q[12]:B
*.pininfo Q[13]:B Q[14]:B Q[15]:B TBWM[8]:B TBWM[9]:B TBWM[10]:B TBWM[11]:B
*.pininfo TBWM[12]:B TBWM[13]:B TBWM[14]:B TBWM[15]:B TD[8]:B TD[9]:B
*.pininfo TD[10]:B TD[11]:B TD[12]:B TD[13]:B TD[14]:B TD[15]:B Q_RED:B
XXGP_GL PWR VDDA VSS BPUC SPUC VNW BADIO[8] BADIO[9] BADIO[10] BADIO[11]
+ BADIO[12] BADIO[13] BADIO[14] BADIO[15] BWM[8] BWM[9] BWM[10] BWM[11]
+ BWM[12] BWM[13] BWM[14] BWM[15] D[8] D[9] D[10] D[11] D[12] D[13] D[14]
+ D[15] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] TBWM[8] TBWM[9]
+ TBWM[10] TBWM[11] TBWM[12] TBWM[13] TBWM[14] TBWM[15] TD[8] TD[9] TD[10]
+ TD[11] TD[12] TD[13] TD[14] TD[15] Q_RED spram_4096x16m16b1pm2re1M16_L m=1
.ends spram_4096x16m16b1pm2re1GP_GL

.subckt spram_4096x16m16b1pm2re1GP BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] VDDA VSS
+ PWR AWT LVTEST VSB400 VSB300 VSB200 VSB100 RA WM[0] WM[1] WM[2] RM[0] RM[1]
+ RM[2] BISTE TCLK CLK TWE WE TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7]
+ TA[8] TA[9] TA[10] TA[11] A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9]
+ A[10] A[11] TCE CE SD HN SL SZ BPUI SPUI CACHE_MISS BADIO[8] BADIO[9]
+ BADIO[10] BADIO[11] BADIO[12] BADIO[13] BADIO[14] BADIO[15] BWM[8] BWM[9]
+ BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[8] D[9] D[10] D[11] D[12]
+ D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] TBWM[8]
+ TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13] TBWM[14] TBWM[15] TD[8] TD[9]
+ TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] Q_RED
*.pininfo BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B
*.pininfo BADIO[6]:B BADIO[7]:B BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B
*.pininfo BWM[5]:B BWM[6]:B BWM[7]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B
*.pininfo D[5]:B D[6]:B D[7]:B Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B
*.pininfo Q[6]:B Q[7]:B TBWM[0]:B TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B
*.pininfo TBWM[5]:B TBWM[6]:B TBWM[7]:B TD[0]:B TD[1]:B TD[2]:B TD[3]:B
*.pininfo TD[4]:B TD[5]:B TD[6]:B TD[7]:B VDDA:B VSS:B PWR:B AWT:B LVTEST:B
*.pininfo VSB400:B VSB300:B VSB200:B VSB100:B RA:B WM[0]:B WM[1]:B WM[2]:B
*.pininfo RM[0]:B RM[1]:B RM[2]:B BISTE:B TCLK:B CLK:B TWE:B WE:B TA[0]:B
*.pininfo TA[1]:B TA[2]:B TA[3]:B TA[4]:B TA[5]:B TA[6]:B TA[7]:B TA[8]:B
*.pininfo TA[9]:B TA[10]:B TA[11]:B A[0]:B A[1]:B A[2]:B A[3]:B A[4]:B A[5]:B
*.pininfo A[6]:B A[7]:B A[8]:B A[9]:B A[10]:B A[11]:B TCE:B CE:B SD:B HN:B
*.pininfo SL:B SZ:B BPUI:B SPUI:B CACHE_MISS:B BADIO[8]:B BADIO[9]:B
*.pininfo BADIO[10]:B BADIO[11]:B BADIO[12]:B BADIO[13]:B BADIO[14]:B
*.pininfo BADIO[15]:B BWM[8]:B BWM[9]:B BWM[10]:B BWM[11]:B BWM[12]:B
*.pininfo BWM[13]:B BWM[14]:B BWM[15]:B D[8]:B D[9]:B D[10]:B D[11]:B D[12]:B
*.pininfo D[13]:B D[14]:B D[15]:B Q[8]:B Q[9]:B Q[10]:B Q[11]:B Q[12]:B
*.pininfo Q[13]:B Q[14]:B Q[15]:B TBWM[8]:B TBWM[9]:B TBWM[10]:B TBWM[11]:B
*.pininfo TBWM[12]:B TBWM[13]:B TBWM[14]:B TBWM[15]:B TD[8]:B TD[9]:B
*.pininfo TD[10]:B TD[11]:B TD[12]:B TD[13]:B TD[14]:B TD[15]:B Q_RED:B
XXspram_4096x16m16b1pm2re1GP_GR_0 BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] PWR VDDA
+ VSS BPUC SPUC VNW spram_4096x16m16b1pm2re1GP_GR m=1
XXspram_4096x16m16b1pm2re1GP_GPG_0 AWT LVTEST VSB400 VSB300 VSB200 VSB100 VSS
+ RA WM[0] WM[1] WM[2] RM[0] RM[1] RM[2] CACHE_MISS BISTE TCLK CLK TWE WE
+ TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10] TA[11]
+ A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] TCE CE SD HN
+ SL SZ BPUI SPUI BPUC SPUC VNW VDDA PWR spram_4096x16m16b1pm2re1GP_GPG m=1
XXspram_4096x16m16b1pm2re1GP_GL_0 BPUC SPUC VNW VSS VDDA PWR BADIO[8]
+ BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13] BADIO[14] BADIO[15] BWM[8]
+ BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[8] D[9] D[10]
+ D[11] D[12] D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15]
+ TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13] TBWM[14] TBWM[15] TD[8]
+ TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] Q_RED
+ spram_4096x16m16b1pm2re1GP_GL m=1
.ends spram_4096x16m16b1pm2re1GP

.subckt spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE Q[0] D[0] TD[0]
+ BWM[0] TBWM[0] BADIO[0] LCLKIO TE SWT VNW VSS VDDA PWR RPIN_OA PREOUT_OA
+ DBR0_OA BWBR0_OA RPFEED[0] RPFEED[1] RPIN PREOUT DBR0 BWBR0 GBW[0] GD[0]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] CS[0] CS[1] CS[2]
+ CS[3]
*.pininfo Q[0]:O D[0]:I TD[0]:I BWM[0]:I TBWM[0]:I BADIO[0]:B LCLKIO:B TE:B
*.pininfo SWT:B VNW:B VSS:B VDDA:B PWR:B RPIN_OA:B PREOUT_OA:B DBR0_OA:B
*.pininfo BWBR0_OA:B RPFEED[0]:B RPFEED[1]:B RPIN:B PREOUT:B DBR0:B BWBR0:B
*.pininfo GBW[0]:B GD[0]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B CS[0]:B CS[1]:B
*.pininfo CS[2]:B CS[3]:B
XXc0r0 BADIO[0] BWM[0] D[0] LBWM_0 LBWMB_0 LCLKIO LDB_0 LD_0 PREOUTQ_0 PWR
+ Q[0] SWT TBWM[0] TD[0] TE VDDA VNW VSS gio4 m=1
XXc1r0 BADIO[0] BWBR0 BWBR0_OA DBR0 DBR0_OA GBW[0] GD[0] LBWM_0 LD_0 PREOUT
+ PREOUTQ_0 PREOUT_OA PWR RPFEED[0] RPFEED[1] RPIN RPIN_OA VDDA VNW VSS
+ red_gio4 m=1
XXc2r0 CS[0] CS[1] CS[2] CS[3] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] PWR PREOUT GRD0[0] GRD1[0] GRD2[0] GRD3[0] VDDA VNW
+ VSS gcsmx4 m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE

.subckt spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY Q[0] D[0] TD[0]
+ BWM[0] TBWM[0] BADIO[0] GBW[0] GD[0] PWR GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] LCLKIO TE SWT VNW VSS VDDA RPIN PREOUT DBR0 BWBR0
+ RPFEED[0] RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[1] D[1] TD[1] BWM[1] TBWM[1]
+ BADIO[1] GBW[1] GD[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] Q[2] D[2] TD[2] BWM[2] TBWM[2] BADIO[2] GBW[2] GD[2] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] Q[3] D[3] TD[3] BWM[3]
+ TBWM[3] BADIO[3] GBW[3] GD[3] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD1[12]
+ GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] Q[4] D[4] TD[4] BWM[4] TBWM[4] BADIO[4] GBW[4]
+ GD[4] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD3[16] GRD3[17] GRD3[18]
+ GRD3[19] Q[5] D[5] TD[5] BWM[5] TBWM[5] BADIO[5] GBW[5] GD[5] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20]
+ GRD2[21] GRD2[22] GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] Q[6] D[6]
+ TD[6] BWM[6] TBWM[6] BADIO[6] GBW[6] GD[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] Q[7] D[7] TD[7] BWM[7] TBWM[7]
+ BADIO[7] GBW[7] GD[7] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
*.pininfo Q[0]:O D[0]:I TD[0]:I BWM[0]:I TBWM[0]:I BADIO[0]:B GBW[0]:B
*.pininfo GD[0]:B PWR:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LCLKIO:B TE:B
*.pininfo SWT:B VNW:B VSS:B VDDA:B RPIN:B PREOUT:B DBR0:B BWBR0:B RPFEED[0]:B
*.pininfo RPFEED[1]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B Q[1]:O D[1]:I TD[1]:I
*.pininfo BWM[1]:I TBWM[1]:I BADIO[1]:B GBW[1]:B GD[1]:B GRD0[4]:B GRD0[5]:B
*.pininfo GRD0[6]:B GRD0[7]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B GRD1[7]:B
*.pininfo GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD3[4]:B GRD3[5]:B
*.pininfo GRD3[6]:B GRD3[7]:B Q[2]:O D[2]:I TD[2]:I BWM[2]:I TBWM[2]:I
*.pininfo BADIO[2]:B GBW[2]:B GD[2]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B
*.pininfo GRD0[11]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD2[8]:B
*.pininfo GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B
*.pininfo GRD3[11]:B Q[3]:O D[3]:I TD[3]:I BWM[3]:I TBWM[3]:I BADIO[3]:B
*.pininfo GBW[3]:B GD[3]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B
*.pininfo GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B
*.pininfo Q[4]:O D[4]:I TD[4]:I BWM[4]:I TBWM[4]:I BADIO[4]:B GBW[4]:B
*.pininfo GD[4]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B Q[5]:O
*.pininfo D[5]:I TD[5]:I BWM[5]:I TBWM[5]:I BADIO[5]:B GBW[5]:B GD[5]:B
*.pininfo GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD1[20]:B GRD1[21]:B
*.pininfo GRD1[22]:B GRD1[23]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B
*.pininfo GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B Q[6]:O D[6]:I TD[6]:I
*.pininfo BWM[6]:I TBWM[6]:I BADIO[6]:B GBW[6]:B GD[6]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B
*.pininfo GRD1[27]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B Q[7]:O D[7]:I TD[7]:I BWM[7]:I
*.pininfo TBWM[7]:I BADIO[7]:B GBW[7]:B GD[7]:B GRD0[28]:B GRD0[29]:B
*.pininfo GRD0[30]:B GRD0[31]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B
*.pininfo GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[28]:B GRD3[29]:B
*.pininfo GRD3[30]:B GRD3[31]:B RPIN_OA:B PREOUT_OA:B DBR0_OA:B BWBR0_OA:B
XX00 Q[0] D[0] TD[0] BWM[0] TBWM[0] BADIO[0] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_0 PREOUT_OA_0 DBR0_OA_0 BWBR0_OA_0 RPFEED[0] RPFEED[1] RPIN PREOUT
+ DBR0 BWBR0 GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
XX01 Q[1] D[1] TD[1] BWM[1] TBWM[1] BADIO[1] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_1 PREOUT_OA_1 DBR0_OA_1 BWBR0_OA_1 RPFEED[0] RPFEED[1] RPIN_OA_0
+ PREOUT_OA_0 DBR0_OA_0 BWBR0_OA_0 GBW[1] GD[1] GRD0[4] GRD0[5] GRD0[6]
+ GRD0[7] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD3[4] GRD3[5] GRD3[6] GRD3[7] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
XX02 Q[2] D[2] TD[2] BWM[2] TBWM[2] BADIO[2] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_2 PREOUT_OA_2 DBR0_OA_2 BWBR0_OA_2 RPFEED[0] RPFEED[1] RPIN_OA_1
+ PREOUT_OA_1 DBR0_OA_1 BWBR0_OA_1 GBW[2] GD[2] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9] GRD2[10]
+ GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
XX03 Q[3] D[3] TD[3] BWM[3] TBWM[3] BADIO[3] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_3 PREOUT_OA_3 DBR0_OA_3 BWBR0_OA_3 RPFEED[0] RPFEED[1] RPIN_OA_2
+ PREOUT_OA_2 DBR0_OA_2 BWBR0_OA_2 GBW[3] GD[3] GRD0[12] GRD0[13] GRD0[14]
+ GRD0[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD3[12] GRD3[13] GRD3[14] GRD3[15] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
XX04 Q[4] D[4] TD[4] BWM[4] TBWM[4] BADIO[4] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_4 PREOUT_OA_4 DBR0_OA_4 BWBR0_OA_4 RPFEED[0] RPFEED[1] RPIN_OA_3
+ PREOUT_OA_3 DBR0_OA_3 BWBR0_OA_3 GBW[4] GD[4] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
XX05 Q[5] D[5] TD[5] BWM[5] TBWM[5] BADIO[5] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_5 PREOUT_OA_5 DBR0_OA_5 BWBR0_OA_5 RPFEED[0] RPFEED[1] RPIN_OA_4
+ PREOUT_OA_4 DBR0_OA_4 BWBR0_OA_4 GBW[5] GD[5] GRD0[20] GRD0[21] GRD0[22]
+ GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
XX06 Q[6] D[6] TD[6] BWM[6] TBWM[6] BADIO[6] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_6 PREOUT_OA_6 DBR0_OA_6 BWBR0_OA_6 RPFEED[0] RPFEED[1] RPIN_OA_5
+ PREOUT_OA_5 DBR0_OA_5 BWBR0_OA_5 GBW[6] GD[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
XX07 Q[7] D[7] TD[7] BWM[7] TBWM[7] BADIO[7] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA RPFEED[0] RPFEED[1] RPIN_OA_6
+ PREOUT_OA_6 DBR0_OA_6 BWBR0_OA_6 GBW[7] GD[7] GRD0[28] GRD0[29] GRD0[30]
+ GRD0[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[28] GRD3[29] GRD3[30] GRD3[31] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_SLICE m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY

.subckt spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA VDDA VSS LCLKIO TE SWT VNW
+ PWR RPIN PREOUT DBR0 BWBR0 RPFEED[0] RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[0]
+ Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7]
+ TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] BWM[0] BWM[1] BWM[2] BWM[3]
+ BWM[4] BWM[5] BWM[6] BWM[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5]
+ BADIO[6] BADIO[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
*.pininfo VDDA:B VSS:B LCLKIO:B TE:B SWT:B VNW:B PWR:B RPIN:B PREOUT:B DBR0:B
*.pininfo BWBR0:B RPFEED[0]:B RPFEED[1]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B
*.pininfo Q[0]:O Q[1]:O Q[2]:O Q[3]:O Q[4]:O Q[5]:O Q[6]:O Q[7]:O D[0]:I
*.pininfo D[1]:I D[2]:I D[3]:I D[4]:I D[5]:I D[6]:I D[7]:I TD[0]:I TD[1]:I
*.pininfo TD[2]:I TD[3]:I TD[4]:I TD[5]:I TD[6]:I TD[7]:I BWM[0]:I BWM[1]:I
*.pininfo BWM[2]:I BWM[3]:I BWM[4]:I BWM[5]:I BWM[6]:I BWM[7]:I TBWM[0]:I
*.pininfo TBWM[1]:I TBWM[2]:I TBWM[3]:I TBWM[4]:I TBWM[5]:I TBWM[6]:I
*.pininfo TBWM[7]:I BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B
*.pininfo BADIO[5]:B BADIO[6]:B BADIO[7]:B GBW[0]:B GBW[1]:B GBW[2]:B
*.pininfo GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B
*.pininfo GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B
*.pininfo GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B
*.pininfo GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B
*.pininfo GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B
*.pininfo GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B
*.pininfo GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B
*.pininfo GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B
*.pininfo GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B
*.pininfo GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B
*.pininfo GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B
*.pininfo GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B
*.pininfo GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B
*.pininfo GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B
*.pininfo GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B
*.pininfo GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B
*.pininfo GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B
*.pininfo GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B
*.pininfo GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B
*.pininfo GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B
*.pininfo GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B
*.pininfo GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B
*.pininfo RPIN_OA:B PREOUT_OA:B DBR0_OA:B BWBR0_OA:B
XXspram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY_0 Q[0] D[0] TD[0] BWM[0]
+ TBWM[0] BADIO[0] GBW[0] GD[0] PWR GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] LCLKIO TE SWT VNW VSS VDDA RPIN PREOUT DBR0 BWBR0 RPFEED[0]
+ RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[1] D[1] TD[1] BWM[1] TBWM[1] BADIO[1]
+ GBW[1] GD[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ Q[2] D[2] TD[2] BWM[2] TBWM[2] BADIO[2] GBW[2] GD[2] GRD0[8] GRD0[9]
+ GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] Q[3] D[3] TD[3] BWM[3]
+ TBWM[3] BADIO[3] GBW[3] GD[3] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD1[12]
+ GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] Q[4] D[4] TD[4] BWM[4] TBWM[4] BADIO[4] GBW[4]
+ GD[4] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD3[16] GRD3[17] GRD3[18]
+ GRD3[19] Q[5] D[5] TD[5] BWM[5] TBWM[5] BADIO[5] GBW[5] GD[5] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20]
+ GRD2[21] GRD2[22] GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] Q[6] D[6]
+ TD[6] BWM[6] TBWM[6] BADIO[6] GBW[6] GD[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] Q[7] D[7] TD[7] BWM[7] TBWM[7]
+ BADIO[7] GBW[7] GD[7] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_GIOARY m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA

.subckt spram_4096x16m16b1pm2re1RE1M16B1_R VSS VDDA PWR CS[0] CS[1] CS[2]
+ CS[3] RPFEED[0] RPFEED[1] LCLKIO TE SWT VNW RPIN_OA PREOUT_OA DBR0_OA
+ BWBR0_OA RPIN PREOUT DBR0 BWBR0 BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] GBW[0]
+ GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3]
+ GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5]
+ GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
*.pininfo VSS:B VDDA:B PWR:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B RPFEED[0]:B
*.pininfo RPFEED[1]:B LCLKIO:B TE:B SWT:B VNW:B RPIN_OA:B PREOUT_OA:B
*.pininfo DBR0_OA:B BWBR0_OA:B RPIN:B PREOUT:B DBR0:B BWBR0:B BADIO[0]:B
*.pininfo BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B BADIO[6]:B
*.pininfo BADIO[7]:B BWM[0]:I BWM[1]:I BWM[2]:I BWM[3]:I BWM[4]:I BWM[5]:I
*.pininfo BWM[6]:I BWM[7]:I D[0]:I D[1]:I D[2]:I D[3]:I D[4]:I D[5]:I D[6]:I
*.pininfo D[7]:I Q[0]:O Q[1]:O Q[2]:O Q[3]:O Q[4]:O Q[5]:O Q[6]:O Q[7]:O
*.pininfo TBWM[0]:I TBWM[1]:I TBWM[2]:I TBWM[3]:I TBWM[4]:I TBWM[5]:I
*.pininfo TBWM[6]:I TBWM[7]:I TD[0]:I TD[1]:I TD[2]:I TD[3]:I TD[4]:I TD[5]:I
*.pininfo TD[6]:I TD[7]:I GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B GBW[4]:B
*.pininfo GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B GD[4]:B
*.pininfo GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.pininfo GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B GRD0[9]:B
*.pininfo GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B
*.pininfo GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B GRD0[21]:B
*.pininfo GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B GRD0[27]:B
*.pininfo GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[0]:B GRD1[1]:B
*.pininfo GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B GRD1[7]:B
*.pininfo GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B GRD1[13]:B
*.pininfo GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B GRD1[19]:B
*.pininfo GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B GRD1[25]:B
*.pininfo GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B
*.pininfo GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B
*.pininfo GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B
*.pininfo GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B
*.pininfo GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B
*.pininfo GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B
*.pininfo GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B
*.pininfo GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B GRD3[9]:B
*.pininfo GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B
*.pininfo GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B GRD3[21]:B
*.pininfo GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B GRD3[27]:B
*.pininfo GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B
XXspram_4096x16m16b1pm2re1RE1M16B1_RARRAYA_0 VDDA VSS LCLKIO TE SWT VNW PWR
+ RPIN PREOUT DBR0 BWBR0 RPFEED[0] RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[0]
+ Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7]
+ TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] BWM[0] BWM[1] BWM[2] BWM[3]
+ BWM[4] BWM[5] BWM[6] BWM[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5]
+ BADIO[6] BADIO[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
+ spram_4096x16m16b1pm2re1RE1M16B1_RARRAYA m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_R

.subckt spram_4096x16m16b1pm2re1GLBIO_GLBIO_R BADIO[0] BADIO[1] BADIO[2]
+ BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3]
+ BWM[4] BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0]
+ Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4]
+ TBWM[5] TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] VSS
+ VDDA GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1]
+ GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4]
+ GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] PWR CSC[0]
+ CSC[1] CSC[2] CSC[3] RPFEED[0] RPFEED[1] LCLKIOC TEC SWTC RPINC PREOUTC
+ DBR0C BWBR0C
*.pininfo BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B
*.pininfo BADIO[6]:B BADIO[7]:B BWM[0]:I BWM[1]:I BWM[2]:I BWM[3]:I BWM[4]:I
*.pininfo BWM[5]:I BWM[6]:I BWM[7]:I D[0]:I D[1]:I D[2]:I D[3]:I D[4]:I
*.pininfo D[5]:I D[6]:I D[7]:I Q[0]:O Q[1]:O Q[2]:O Q[3]:O Q[4]:O Q[5]:O
*.pininfo Q[6]:O Q[7]:O TBWM[0]:I TBWM[1]:I TBWM[2]:I TBWM[3]:I TBWM[4]:I
*.pininfo TBWM[5]:I TBWM[6]:I TBWM[7]:I TD[0]:I TD[1]:I TD[2]:I TD[3]:I
*.pininfo TD[4]:I TD[5]:I TD[6]:I TD[7]:I VSS:B VDDA:B GBW[0]:B GBW[1]:B
*.pininfo GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B
*.pininfo GD[1]:B GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B
*.pininfo GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B
*.pininfo GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B
*.pininfo GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B
*.pininfo GRD0[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B
*.pininfo GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B
*.pininfo GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B
*.pininfo GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B
*.pininfo GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B
*.pininfo GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B
*.pininfo GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B
*.pininfo GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B
*.pininfo GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B
*.pininfo GRD3[31]:B PWR:B CSC[0]:B CSC[1]:B CSC[2]:B CSC[3]:B RPFEED[0]:B
*.pininfo RPFEED[1]:B LCLKIOC:B TEC:B SWTC:B RPINC:B PREOUTC:B DBR0C:B
*.pininfo BWBR0C:B
XXGLBIO_GLBIO_R VSS VDDA PWR CSC[0] CSC[1] CSC[2] CSC[3] RPFEED[0] RPFEED[1]
+ LCLKIOC TEC SWTC VDDA RPINC PREOUTC DBR0C BWBR0C RPIN PREOUT DBR0 BWBR0
+ BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5] BADIO[6] BADIO[7]
+ BWM[0] BWM[1] BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3]
+ D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1]
+ TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3]
+ TD[4] TD[5] TD[6] TD[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6]
+ GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] spram_4096x16m16b1pm2re1RE1M16B1_R m=1
.ends spram_4096x16m16b1pm2re1GLBIO_GLBIO_R

.subckt spram_4096x16m16b1pm2re1GLBIO_GLBCEN BPUI SPUI AWT VDDA VSS LVTEST
+ VSB400 VSB300 VSB200 VSB100 RA WM[0] WM[1] WM[2] RM[0] RM[1] RM[2] BISTE
+ TCLK CLK TWE WE TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9]
+ TA[10] TA[11] A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11]
+ TCE CE SD HN SL SZ PWR EN ENB RMO[0] RMO[1] RMO[2] WMO[0] WMO[1] WMO[2]
+ ag_ctrl T1EN ZRR CSH_RR CSH_LD CSH_ENB RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] VSB[1] VSB[2] VSB[3] VSB[4] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+ QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] GRST LCLKIOC TEC SWTC RPINC PREOUTC
+ DBR0C BWBR0C CSC[0] CSC[1] CSC[2] CSC[3] BSC[0] BSC[1] BSC[2] BSC[3]
*.pininfo BPUI:B SPUI:B AWT:B VDDA:B VSS:B LVTEST:I VSB400:B VSB300:B
*.pininfo VSB200:B VSB100:B RA:I WM[0]:I WM[1]:I WM[2]:I RM[0]:I RM[1]:I
*.pininfo RM[2]:I BISTE:B TCLK:I CLK:I TWE:I WE:I TA[0]:I TA[1]:I TA[2]:I
*.pininfo TA[3]:I TA[4]:I TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I
*.pininfo TA[11]:I A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I
*.pininfo A[8]:I A[9]:I A[10]:I A[11]:I TCE:I CE:I SD:B HN:B SL:B SZ:B PWR:B
*.pininfo EN:O ENB:O RMO[0]:O RMO[1]:O RMO[2]:O WMO[0]:O WMO[1]:O WMO[2]:O
*.pininfo ag_ctrl:B T1EN:O ZRR:O CSH_RR:O CSH_LD:O CSH_ENB:O RWOUT:O
*.pininfo CSH_YS[0]:O CSH_YS[1]:O CSH_YS[2]:O CSH_YS[3]:O VSB[1]:B VSB[2]:B
*.pininfo VSB[3]:B VSB[4]:B QT[2]:O QT[3]:O QT[4]:O QT[5]:O QT[6]:O QT[7]:O
*.pininfo QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O QT[13]:O GRST:I
*.pininfo LCLKIOC:O TEC:B SWTC:B RPINC:B PREOUTC:B DBR0C:B BWBR0C:B CSC[0]:O
*.pininfo CSC[1]:O CSC[2]:O CSC[3]:O BSC[0]:O BSC[1]:O BSC[2]:O BSC[3]:O
XXGLBIO_GLBCEN A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11]
+ VSS VSS AWT BISTE VSS VSS BPUI BSC[0] BSC[1] BSC[2] BSC[3] BWBR0C VSS
+ CACHE_MISS CE CLK CSC[0] CSC[1] CSC[2] CSC[3] CSH_ENB CSH_LD CSH_RR
+ CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBR0C EN ENB GRST HN LCLKIOC
+ PREOUTC PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RA RM[0] RM[1] RM[2] RMO[0] RMO[1] RMO[2] RPINC VSS RWOUT SD
+ SL SPUI SWTC SZ T1EN TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8]
+ TA[9] TA[10] TA[11] VSS VSS VSS TCE TCLK TEC LVTEST VSS TWE VDDA VDDA
+ VSB100 VSB200 VSB300 VSB400 VSB[1] VSB[2] VSB[3] VSB[4] VSS WE WM[0] WM[1]
+ WM[2] WMO[0] WMO[1] WMO[2] ZRR ag_ctrl gctl_cache_cm8 m=1
.ends spram_4096x16m16b1pm2re1GLBIO_GLBCEN

.subckt spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE Q[0] D[0] TD[0]
+ BWM[0] TBWM[0] BADIO[0] LCLKIO TE SWT VNW VSS VDDA PWR RPIN_OA PREOUT_OA
+ DBR0_OA BWBR0_OA RPFEED[0] RPFEED[1] RPIN PREOUT DBR0 BWBR0 GBW[0] GD[0]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] CS[0] CS[1] CS[2]
+ CS[3]
*.pininfo Q[0]:O D[0]:I TD[0]:I BWM[0]:I TBWM[0]:I BADIO[0]:B LCLKIO:B TE:B
*.pininfo SWT:B VNW:B VSS:B VDDA:B PWR:B RPIN_OA:B PREOUT_OA:B DBR0_OA:B
*.pininfo BWBR0_OA:B RPFEED[0]:B RPFEED[1]:B RPIN:B PREOUT:B DBR0:B BWBR0:B
*.pininfo GBW[0]:B GD[0]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B CS[0]:B CS[1]:B
*.pininfo CS[2]:B CS[3]:B
XXc0r0 BADIO[0] BWM[0] D[0] LBWM_0 LBWMB_0 LCLKIO LDB_0 LD_0 PREOUTQ_0 PWR
+ Q[0] SWT TBWM[0] TD[0] TE VDDA VNW VSS gio4 m=1
XXc1r0 BADIO[0] BWBR0 BWBR0_OA DBR0 DBR0_OA GBW[0] GD[0] LBWM_0 LD_0 PREOUT
+ PREOUTQ_0 PREOUT_OA PWR RPFEED[0] RPFEED[1] RPIN RPIN_OA VDDA VNW VSS
+ red_gio4 m=1
XXc2r0 CS[0] CS[1] CS[2] CS[3] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] PWR PREOUT GRD0[0] GRD1[0] GRD2[0] GRD3[0] VDDA VNW
+ VSS gcsmx4 m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE

.subckt spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY Q[0] D[0] TD[0]
+ BWM[0] TBWM[0] BADIO[0] GBW[0] GD[0] PWR GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] LCLKIO TE SWT VNW VSS VDDA RPIN PREOUT DBR0 BWBR0
+ RPFEED[0] RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[1] D[1] TD[1] BWM[1] TBWM[1]
+ BADIO[1] GBW[1] GD[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] Q[2] D[2] TD[2] BWM[2] TBWM[2] BADIO[2] GBW[2] GD[2] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] Q[3] D[3] TD[3] BWM[3]
+ TBWM[3] BADIO[3] GBW[3] GD[3] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD1[12]
+ GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] Q[4] D[4] TD[4] BWM[4] TBWM[4] BADIO[4] GBW[4]
+ GD[4] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD3[16] GRD3[17] GRD3[18]
+ GRD3[19] Q[5] D[5] TD[5] BWM[5] TBWM[5] BADIO[5] GBW[5] GD[5] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20]
+ GRD2[21] GRD2[22] GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] Q[6] D[6]
+ TD[6] BWM[6] TBWM[6] BADIO[6] GBW[6] GD[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] Q[7] D[7] TD[7] BWM[7] TBWM[7]
+ BADIO[7] GBW[7] GD[7] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
*.pininfo Q[0]:O D[0]:I TD[0]:I BWM[0]:I TBWM[0]:I BADIO[0]:B GBW[0]:B
*.pininfo GD[0]:B PWR:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LCLKIO:B TE:B
*.pininfo SWT:B VNW:B VSS:B VDDA:B RPIN:B PREOUT:B DBR0:B BWBR0:B RPFEED[0]:B
*.pininfo RPFEED[1]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B Q[1]:O D[1]:I TD[1]:I
*.pininfo BWM[1]:I TBWM[1]:I BADIO[1]:B GBW[1]:B GD[1]:B GRD0[4]:B GRD0[5]:B
*.pininfo GRD0[6]:B GRD0[7]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B GRD1[7]:B
*.pininfo GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD3[4]:B GRD3[5]:B
*.pininfo GRD3[6]:B GRD3[7]:B Q[2]:O D[2]:I TD[2]:I BWM[2]:I TBWM[2]:I
*.pininfo BADIO[2]:B GBW[2]:B GD[2]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B
*.pininfo GRD0[11]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD2[8]:B
*.pininfo GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B
*.pininfo GRD3[11]:B Q[3]:O D[3]:I TD[3]:I BWM[3]:I TBWM[3]:I BADIO[3]:B
*.pininfo GBW[3]:B GD[3]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B
*.pininfo GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B
*.pininfo Q[4]:O D[4]:I TD[4]:I BWM[4]:I TBWM[4]:I BADIO[4]:B GBW[4]:B
*.pininfo GD[4]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B Q[5]:O
*.pininfo D[5]:I TD[5]:I BWM[5]:I TBWM[5]:I BADIO[5]:B GBW[5]:B GD[5]:B
*.pininfo GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD1[20]:B GRD1[21]:B
*.pininfo GRD1[22]:B GRD1[23]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B
*.pininfo GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B Q[6]:O D[6]:I TD[6]:I
*.pininfo BWM[6]:I TBWM[6]:I BADIO[6]:B GBW[6]:B GD[6]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B
*.pininfo GRD1[27]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B Q[7]:O D[7]:I TD[7]:I BWM[7]:I
*.pininfo TBWM[7]:I BADIO[7]:B GBW[7]:B GD[7]:B GRD0[28]:B GRD0[29]:B
*.pininfo GRD0[30]:B GRD0[31]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B
*.pininfo GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[28]:B GRD3[29]:B
*.pininfo GRD3[30]:B GRD3[31]:B RPIN_OA:B PREOUT_OA:B DBR0_OA:B BWBR0_OA:B
XX00 Q[0] D[0] TD[0] BWM[0] TBWM[0] BADIO[0] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_0 PREOUT_OA_0 DBR0_OA_0 BWBR0_OA_0 RPFEED[0] RPFEED[1] RPIN PREOUT
+ DBR0 BWBR0 GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
XX01 Q[1] D[1] TD[1] BWM[1] TBWM[1] BADIO[1] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_1 PREOUT_OA_1 DBR0_OA_1 BWBR0_OA_1 RPFEED[0] RPFEED[1] RPIN_OA_0
+ PREOUT_OA_0 DBR0_OA_0 BWBR0_OA_0 GBW[1] GD[1] GRD0[4] GRD0[5] GRD0[6]
+ GRD0[7] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD3[4] GRD3[5] GRD3[6] GRD3[7] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
XX02 Q[2] D[2] TD[2] BWM[2] TBWM[2] BADIO[2] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_2 PREOUT_OA_2 DBR0_OA_2 BWBR0_OA_2 RPFEED[0] RPFEED[1] RPIN_OA_1
+ PREOUT_OA_1 DBR0_OA_1 BWBR0_OA_1 GBW[2] GD[2] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9] GRD2[10]
+ GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
XX03 Q[3] D[3] TD[3] BWM[3] TBWM[3] BADIO[3] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_3 PREOUT_OA_3 DBR0_OA_3 BWBR0_OA_3 RPFEED[0] RPFEED[1] RPIN_OA_2
+ PREOUT_OA_2 DBR0_OA_2 BWBR0_OA_2 GBW[3] GD[3] GRD0[12] GRD0[13] GRD0[14]
+ GRD0[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD3[12] GRD3[13] GRD3[14] GRD3[15] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
XX04 Q[4] D[4] TD[4] BWM[4] TBWM[4] BADIO[4] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_4 PREOUT_OA_4 DBR0_OA_4 BWBR0_OA_4 RPFEED[0] RPFEED[1] RPIN_OA_3
+ PREOUT_OA_3 DBR0_OA_3 BWBR0_OA_3 GBW[4] GD[4] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
XX05 Q[5] D[5] TD[5] BWM[5] TBWM[5] BADIO[5] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_5 PREOUT_OA_5 DBR0_OA_5 BWBR0_OA_5 RPFEED[0] RPFEED[1] RPIN_OA_4
+ PREOUT_OA_4 DBR0_OA_4 BWBR0_OA_4 GBW[5] GD[5] GRD0[20] GRD0[21] GRD0[22]
+ GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
XX06 Q[6] D[6] TD[6] BWM[6] TBWM[6] BADIO[6] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA_6 PREOUT_OA_6 DBR0_OA_6 BWBR0_OA_6 RPFEED[0] RPFEED[1] RPIN_OA_5
+ PREOUT_OA_5 DBR0_OA_5 BWBR0_OA_5 GBW[6] GD[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
XX07 Q[7] D[7] TD[7] BWM[7] TBWM[7] BADIO[7] LCLKIO TE SWT VNW VSS VDDA PWR
+ RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA RPFEED[0] RPFEED[1] RPIN_OA_6
+ PREOUT_OA_6 DBR0_OA_6 BWBR0_OA_6 GBW[7] GD[7] GRD0[28] GRD0[29] GRD0[30]
+ GRD0[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[28] GRD3[29] GRD3[30] GRD3[31] CS[0] CS[1] CS[2] CS[3]
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_SLICE m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY

.subckt spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIORE VSS Q_RED LCLKIO TE
+ SWT VNW VDDA PWR RPOUT PREOUTS DBR1 BWBR1 RPFEED[0] RPFEED[1] RPIN PREOUT
+ DBR0 BWBR0 RGBW RGD RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] CS[0] CS[1] CS[2] CS[3]
*.pininfo VSS:B Q_RED:O LCLKIO:B TE:B SWT:B VNW:B VDDA:B PWR:B RPOUT:B
*.pininfo PREOUTS:B DBR1:B BWBR1:B RPFEED[0]:B RPFEED[1]:B RPIN:B PREOUT:B
*.pininfo DBR0:B BWBR0:B RGBW:B RGD:B RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B
*.pininfo RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD2[0]:B
*.pininfo RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B
*.pininfo RGRD3[3]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B
XXc0r0 VSS VSS VSS LBWM_0 LBWMB_0 LCLKIO LDB_0 LD_0 PREOUTQ_0 PWR Q_RED SWT
+ VSS VSS TE VDDA VNW VSS gio4 m=1
XXc1r0 VSS BWBR0 BWBR1 DBR0 DBR1 RGBW RGD LBWM_0 LD_0 PREOUT PREOUTQ_0
+ PREOUTS PWR RPFEED[0] RPFEED[1] RPIN RPOUT VDDA VNW VSS red_gio4 m=1
XXc2r0 CS[0] CS[1] CS[2] CS[3] RGBW RGD RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3]
+ RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3]
+ RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] PWR PREOUT RGRD0[0] RGRD1[0] RGRD2[0]
+ RGRD3[0] VDDA VNW VSS gcsmx4 m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIORE

.subckt spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIO_RED Q_RED RGBW RGD PWR
+ RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3]
+ RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3]
+ LCLKIO TE SWT VNW VSS VDDA RPIN_OB PREOUT_OB DBR0_OB BWBR0_OB RPFEED[0]
+ RPFEED[1] CS[0] CS[1] CS[2] CS[3] RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
*.pininfo Q_RED:O RGBW:B RGD:B PWR:B RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B
*.pininfo RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD2[0]:B
*.pininfo RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B
*.pininfo RGRD3[3]:B LCLKIO:B TE:B SWT:B VNW:B VSS:B VDDA:B RPIN_OB:B
*.pininfo PREOUT_OB:B DBR0_OB:B BWBR0_OB:B RPFEED[0]:B RPFEED[1]:B CS[0]:B
*.pininfo CS[1]:B CS[2]:B CS[3]:B RPIN_OA:B PREOUT_OA:B DBR0_OA:B BWBR0_OA:B
XX00 VSS Q_RED LCLKIO TE SWT VNW VDDA PWR RPIN_OB PREOUT_OB DBR0_OB BWBR0_OB
+ RPFEED[0] RPFEED[1] RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA RGBW RGD RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0]
+ RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] CS[0] CS[1]
+ CS[2] CS[3] spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIORE m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIO_RED

.subckt spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA VDDA VSS LCLKIO TE SWT VNW
+ PWR RPIN PREOUT DBR0 BWBR0 RPFEED[0] RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[0]
+ Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7]
+ TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] BWM[0] BWM[1] BWM[2] BWM[3]
+ BWM[4] BWM[5] BWM[6] BWM[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5]
+ BADIO[6] BADIO[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ Q_RED RGBW RGD RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RPIN_OB PREOUT_OB DBR0_OB BWBR0_OB
*.pininfo VDDA:B VSS:B LCLKIO:B TE:B SWT:B VNW:B PWR:B RPIN:B PREOUT:B DBR0:B
*.pininfo BWBR0:B RPFEED[0]:B RPFEED[1]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B
*.pininfo Q[0]:O Q[1]:O Q[2]:O Q[3]:O Q[4]:O Q[5]:O Q[6]:O Q[7]:O D[0]:I
*.pininfo D[1]:I D[2]:I D[3]:I D[4]:I D[5]:I D[6]:I D[7]:I TD[0]:I TD[1]:I
*.pininfo TD[2]:I TD[3]:I TD[4]:I TD[5]:I TD[6]:I TD[7]:I BWM[0]:I BWM[1]:I
*.pininfo BWM[2]:I BWM[3]:I BWM[4]:I BWM[5]:I BWM[6]:I BWM[7]:I TBWM[0]:I
*.pininfo TBWM[1]:I TBWM[2]:I TBWM[3]:I TBWM[4]:I TBWM[5]:I TBWM[6]:I
*.pininfo TBWM[7]:I BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B
*.pininfo BADIO[5]:B BADIO[6]:B BADIO[7]:B GBW[0]:B GBW[1]:B GBW[2]:B
*.pininfo GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B
*.pininfo GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B
*.pininfo GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B
*.pininfo GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B
*.pininfo GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B
*.pininfo GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B
*.pininfo GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B
*.pininfo GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B
*.pininfo GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B
*.pininfo GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B
*.pininfo GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B
*.pininfo GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B
*.pininfo GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B
*.pininfo GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B
*.pininfo GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B
*.pininfo GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B
*.pininfo GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B
*.pininfo GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B
*.pininfo GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B
*.pininfo GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B
*.pininfo GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B
*.pininfo GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B
*.pininfo Q_RED:O RGBW:B RGD:B RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B
*.pininfo RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD2[0]:B RGRD2[1]:B
*.pininfo RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B
*.pininfo RPIN_OB:B PREOUT_OB:B DBR0_OB:B BWBR0_OB:B
XXspram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY_0 Q[0] D[0] TD[0] BWM[0]
+ TBWM[0] BADIO[0] GBW[0] GD[0] PWR GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] LCLKIO TE SWT VNW VSS VDDA RPIN PREOUT DBR0 BWBR0 RPFEED[0]
+ RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[1] D[1] TD[1] BWM[1] TBWM[1] BADIO[1]
+ GBW[1] GD[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ Q[2] D[2] TD[2] BWM[2] TBWM[2] BADIO[2] GBW[2] GD[2] GRD0[8] GRD0[9]
+ GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] Q[3] D[3] TD[3] BWM[3]
+ TBWM[3] BADIO[3] GBW[3] GD[3] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD1[12]
+ GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] Q[4] D[4] TD[4] BWM[4] TBWM[4] BADIO[4] GBW[4]
+ GD[4] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD3[16] GRD3[17] GRD3[18]
+ GRD3[19] Q[5] D[5] TD[5] BWM[5] TBWM[5] BADIO[5] GBW[5] GD[5] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20]
+ GRD2[21] GRD2[22] GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] Q[6] D[6]
+ TD[6] BWM[6] TBWM[6] BADIO[6] GBW[6] GD[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] Q[7] D[7] TD[7] BWM[7] TBWM[7]
+ BADIO[7] GBW[7] GD[7] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIOARY m=1
XXspram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIO_RED_0 Q_RED RGBW RGD PWR
+ RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3]
+ RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3]
+ LCLKIO TE SWT VNW VSS VDDA RPIN_OB PREOUT_OB DBR0_OB BWBR0_OB RPFEED[0]
+ RPFEED[1] CS[0] CS[1] CS[2] CS[3] RPIN_OA PREOUT_OA DBR0_OA BWBR0_OA
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_GIO_RED m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA

.subckt spram_4096x16m16b1pm2re1RE1M16B1_L VSS VDDA PWR CS[0] CS[1] CS[2]
+ CS[3] RPFEED[0] RPFEED[1] LCLKIO TE SWT VNW RPIN_OB PREOUT_OB DBR0_OB
+ BWBR0_OB RPIN PREOUT DBR0 BWBR0 BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] Q_RED
+ GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2]
+ GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4]
+ GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0]
+ RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGBW RGD
*.pininfo VSS:B VDDA:B PWR:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B RPFEED[0]:B
*.pininfo RPFEED[1]:B LCLKIO:B TE:B SWT:B VNW:B RPIN_OB:B PREOUT_OB:B
*.pininfo DBR0_OB:B BWBR0_OB:B RPIN:B PREOUT:B DBR0:B BWBR0:B BADIO[0]:B
*.pininfo BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B BADIO[6]:B
*.pininfo BADIO[7]:B BWM[0]:I BWM[1]:I BWM[2]:I BWM[3]:I BWM[4]:I BWM[5]:I
*.pininfo BWM[6]:I BWM[7]:I D[0]:I D[1]:I D[2]:I D[3]:I D[4]:I D[5]:I D[6]:I
*.pininfo D[7]:I Q[0]:O Q[1]:O Q[2]:O Q[3]:O Q[4]:O Q[5]:O Q[6]:O Q[7]:O
*.pininfo TBWM[0]:I TBWM[1]:I TBWM[2]:I TBWM[3]:I TBWM[4]:I TBWM[5]:I
*.pininfo TBWM[6]:I TBWM[7]:I TD[0]:I TD[1]:I TD[2]:I TD[3]:I TD[4]:I TD[5]:I
*.pininfo TD[6]:I TD[7]:I Q_RED:O GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B
*.pininfo GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B
*.pininfo GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B
*.pininfo GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B
*.pininfo GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B
*.pininfo GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B
*.pininfo GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B
*.pininfo GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B
*.pininfo GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B
*.pininfo GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B RGRD0[0]:B
*.pininfo RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B
*.pininfo RGRD1[3]:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B
*.pininfo RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B RGBW:B RGD:B
XXspram_4096x16m16b1pm2re1RE1M16B1_LARRAYA_0 VDDA VSS LCLKIO TE SWT VNW PWR
+ RPIN PREOUT DBR0 BWBR0 RPFEED[0] RPFEED[1] CS[0] CS[1] CS[2] CS[3] Q[0]
+ Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7]
+ TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] BWM[0] BWM[1] BWM[2] BWM[3]
+ BWM[4] BWM[5] BWM[6] BWM[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5]
+ BADIO[6] BADIO[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ Q_RED RGBW RGD RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RPIN_OB PREOUT_OB DBR0_OB BWBR0_OB
+ spram_4096x16m16b1pm2re1RE1M16B1_LARRAYA m=1
.ends spram_4096x16m16b1pm2re1RE1M16B1_L

.subckt spram_4096x16m16b1pm2re1GLBIO_GLBIO_L CSC[0] CSC[1] CSC[2] CSC[3]
+ RPFEED[0] RPFEED[1] LCLKIOC TEC SWTC VDDA VSS PWR RPINC PREOUTC DBR0C
+ BWBR0C BADIO[8] BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13] BADIO[14]
+ BADIO[15] BWM[8] BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15]
+ D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12]
+ Q[13] Q[14] Q[15] TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13]
+ TBWM[14] TBWM[15] TD[8] TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15]
+ Q_RED GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8]
+ GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34]
+ GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42]
+ GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50]
+ GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58]
+ GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34]
+ GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42]
+ GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50]
+ GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58]
+ GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34]
+ GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42]
+ GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50]
+ GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58]
+ GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] RGRD0[0] RGRD0[1] RGRD0[2]
+ RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2]
+ RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGBW RGD
*.pininfo CSC[0]:B CSC[1]:B CSC[2]:B CSC[3]:B RPFEED[0]:B RPFEED[1]:B
*.pininfo LCLKIOC:B TEC:B SWTC:B VDDA:B VSS:B PWR:B RPINC:B PREOUTC:B DBR0C:B
*.pininfo BWBR0C:B BADIO[8]:B BADIO[9]:B BADIO[10]:B BADIO[11]:B BADIO[12]:B
*.pininfo BADIO[13]:B BADIO[14]:B BADIO[15]:B BWM[8]:I BWM[9]:I BWM[10]:I
*.pininfo BWM[11]:I BWM[12]:I BWM[13]:I BWM[14]:I BWM[15]:I D[8]:I D[9]:I
*.pininfo D[10]:I D[11]:I D[12]:I D[13]:I D[14]:I D[15]:I Q[8]:O Q[9]:O
*.pininfo Q[10]:O Q[11]:O Q[12]:O Q[13]:O Q[14]:O Q[15]:O TBWM[8]:I TBWM[9]:I
*.pininfo TBWM[10]:I TBWM[11]:I TBWM[12]:I TBWM[13]:I TBWM[14]:I TBWM[15]:I
*.pininfo TD[8]:I TD[9]:I TD[10]:I TD[11]:I TD[12]:I TD[13]:I TD[14]:I
*.pininfo TD[15]:I Q_RED:O GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B
*.pininfo GBW[13]:B GBW[14]:B GBW[15]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B
*.pininfo GD[12]:B GD[13]:B GD[14]:B GD[15]:B GRD0[32]:B GRD0[33]:B
*.pininfo GRD0[34]:B GRD0[35]:B GRD0[36]:B GRD0[37]:B GRD0[38]:B GRD0[39]:B
*.pininfo GRD0[40]:B GRD0[41]:B GRD0[42]:B GRD0[43]:B GRD0[44]:B GRD0[45]:B
*.pininfo GRD0[46]:B GRD0[47]:B GRD0[48]:B GRD0[49]:B GRD0[50]:B GRD0[51]:B
*.pininfo GRD0[52]:B GRD0[53]:B GRD0[54]:B GRD0[55]:B GRD0[56]:B GRD0[57]:B
*.pininfo GRD0[58]:B GRD0[59]:B GRD0[60]:B GRD0[61]:B GRD0[62]:B GRD0[63]:B
*.pininfo GRD1[32]:B GRD1[33]:B GRD1[34]:B GRD1[35]:B GRD1[36]:B GRD1[37]:B
*.pininfo GRD1[38]:B GRD1[39]:B GRD1[40]:B GRD1[41]:B GRD1[42]:B GRD1[43]:B
*.pininfo GRD1[44]:B GRD1[45]:B GRD1[46]:B GRD1[47]:B GRD1[48]:B GRD1[49]:B
*.pininfo GRD1[50]:B GRD1[51]:B GRD1[52]:B GRD1[53]:B GRD1[54]:B GRD1[55]:B
*.pininfo GRD1[56]:B GRD1[57]:B GRD1[58]:B GRD1[59]:B GRD1[60]:B GRD1[61]:B
*.pininfo GRD1[62]:B GRD1[63]:B GRD2[32]:B GRD2[33]:B GRD2[34]:B GRD2[35]:B
*.pininfo GRD2[36]:B GRD2[37]:B GRD2[38]:B GRD2[39]:B GRD2[40]:B GRD2[41]:B
*.pininfo GRD2[42]:B GRD2[43]:B GRD2[44]:B GRD2[45]:B GRD2[46]:B GRD2[47]:B
*.pininfo GRD2[48]:B GRD2[49]:B GRD2[50]:B GRD2[51]:B GRD2[52]:B GRD2[53]:B
*.pininfo GRD2[54]:B GRD2[55]:B GRD2[56]:B GRD2[57]:B GRD2[58]:B GRD2[59]:B
*.pininfo GRD2[60]:B GRD2[61]:B GRD2[62]:B GRD2[63]:B GRD3[32]:B GRD3[33]:B
*.pininfo GRD3[34]:B GRD3[35]:B GRD3[36]:B GRD3[37]:B GRD3[38]:B GRD3[39]:B
*.pininfo GRD3[40]:B GRD3[41]:B GRD3[42]:B GRD3[43]:B GRD3[44]:B GRD3[45]:B
*.pininfo GRD3[46]:B GRD3[47]:B GRD3[48]:B GRD3[49]:B GRD3[50]:B GRD3[51]:B
*.pininfo GRD3[52]:B GRD3[53]:B GRD3[54]:B GRD3[55]:B GRD3[56]:B GRD3[57]:B
*.pininfo GRD3[58]:B GRD3[59]:B GRD3[60]:B GRD3[61]:B GRD3[62]:B GRD3[63]:B
*.pininfo RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B
*.pininfo RGRD1[2]:B RGRD1[3]:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B
*.pininfo RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B RGBW:B RGD:B
XXGLBIO_GLBIO_L VSS VDDA PWR CSC[0] CSC[1] CSC[2] CSC[3] RPFEED[0] RPFEED[1]
+ LCLKIOC TEC SWTC VDDA RPIN_OB PREOUT_OB DBR0_OB BWBR0_OB RPINC PREOUTC
+ DBR0C BWBR0C BADIO[8] BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13]
+ BADIO[14] BADIO[15] BWM[8] BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14]
+ BWM[15] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11]
+ Q[12] Q[13] Q[14] Q[15] TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13]
+ TBWM[14] TBWM[15] TD[8] TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15]
+ Q_RED GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8]
+ GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34]
+ GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42]
+ GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50]
+ GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58]
+ GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34]
+ GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42]
+ GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50]
+ GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58]
+ GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34]
+ GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42]
+ GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50]
+ GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58]
+ GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] RGRD0[0] RGRD0[1] RGRD0[2]
+ RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2]
+ RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGBW RGD
+ spram_4096x16m16b1pm2re1RE1M16B1_L m=1
.ends spram_4096x16m16b1pm2re1GLBIO_GLBIO_L

.subckt spram_4096x16m16b1pm2re1GLBIO BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] VSS VDDA
+ GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2]
+ GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4]
+ GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] PWR BPUI
+ SPUI AWT LVTEST VSB400 VSB300 VSB200 VSB100 RA WM[0] WM[1] WM[2] RM[0]
+ RM[1] RM[2] BISTE TCLK CLK TWE WE TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6]
+ TA[7] TA[8] TA[9] TA[10] TA[11] A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7]
+ A[8] A[9] A[10] A[11] TCE CE SD HN SL SZ EN ENB RMO[0] RMO[1] RMO[2] WMO[0]
+ WMO[1] WMO[2] ag_ctrl T0EN ZRR CSH_RR CSH_LD CSH_ENB RWOUT CSH_YS[0]
+ CSH_YS[1] CSH_YS[2] CSH_YS[3] VSB[1] VSB[2] VSB[3] VSB[4] QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] GRST BADIO[8]
+ BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13] BADIO[14] BADIO[15] BWM[8]
+ BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[8] D[9] D[10]
+ D[11] D[12] D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15]
+ TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13] TBWM[14] TBWM[15] TD[8]
+ TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] Q_RED GBW[8] GBW[9] GBW[10]
+ GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12]
+ GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37]
+ GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45]
+ GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53]
+ GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61]
+ GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37]
+ GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45]
+ GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53]
+ GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61]
+ GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37]
+ GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45]
+ GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53]
+ GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61]
+ GRD3[62] GRD3[63] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RGBW RGD
*.pininfo BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B BADIO[4]:B BADIO[5]:B
*.pininfo BADIO[6]:B BADIO[7]:B BWM[0]:I BWM[1]:I BWM[2]:I BWM[3]:I BWM[4]:I
*.pininfo BWM[5]:I BWM[6]:I BWM[7]:I D[0]:I D[1]:I D[2]:I D[3]:I D[4]:I
*.pininfo D[5]:I D[6]:I D[7]:I Q[0]:O Q[1]:O Q[2]:O Q[3]:O Q[4]:O Q[5]:O
*.pininfo Q[6]:O Q[7]:O TBWM[0]:I TBWM[1]:I TBWM[2]:I TBWM[3]:I TBWM[4]:I
*.pininfo TBWM[5]:I TBWM[6]:I TBWM[7]:I TD[0]:I TD[1]:I TD[2]:I TD[3]:I
*.pininfo TD[4]:I TD[5]:I TD[6]:I TD[7]:I VSS:B VDDA:B GBW[0]:B GBW[1]:B
*.pininfo GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B
*.pininfo GD[1]:B GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B
*.pininfo GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B
*.pininfo GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B
*.pininfo GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B
*.pininfo GRD0[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B
*.pininfo GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B
*.pininfo GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B
*.pininfo GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B
*.pininfo GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B
*.pininfo GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B
*.pininfo GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B
*.pininfo GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B
*.pininfo GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B
*.pininfo GRD3[31]:B PWR:B BPUI:B SPUI:B AWT:B LVTEST:I VSB400:B VSB300:B
*.pininfo VSB200:B VSB100:B RA:I WM[0]:I WM[1]:I WM[2]:I RM[0]:I RM[1]:I
*.pininfo RM[2]:I BISTE:B TCLK:I CLK:I TWE:I WE:I TA[0]:I TA[1]:I TA[2]:I
*.pininfo TA[3]:I TA[4]:I TA[5]:I TA[6]:I TA[7]:I TA[8]:I TA[9]:I TA[10]:I
*.pininfo TA[11]:I A[0]:I A[1]:I A[2]:I A[3]:I A[4]:I A[5]:I A[6]:I A[7]:I
*.pininfo A[8]:I A[9]:I A[10]:I A[11]:I TCE:I CE:I SD:B HN:B SL:B SZ:B EN:O
*.pininfo ENB:O RMO[0]:O RMO[1]:O RMO[2]:O WMO[0]:O WMO[1]:O WMO[2]:O
*.pininfo ag_ctrl:B T0EN:O ZRR:O CSH_RR:O CSH_LD:O CSH_ENB:O RWOUT:O
*.pininfo CSH_YS[0]:O CSH_YS[1]:O CSH_YS[2]:O CSH_YS[3]:O VSB[1]:B VSB[2]:B
*.pininfo VSB[3]:B VSB[4]:B QT[2]:O QT[3]:O QT[4]:O QT[5]:O QT[6]:O QT[7]:O
*.pininfo QT[8]:O QT[9]:O QT[10]:O QT[11]:O QT[12]:O QT[13]:O GRST:I
*.pininfo BADIO[8]:B BADIO[9]:B BADIO[10]:B BADIO[11]:B BADIO[12]:B
*.pininfo BADIO[13]:B BADIO[14]:B BADIO[15]:B BWM[8]:I BWM[9]:I BWM[10]:I
*.pininfo BWM[11]:I BWM[12]:I BWM[13]:I BWM[14]:I BWM[15]:I D[8]:I D[9]:I
*.pininfo D[10]:I D[11]:I D[12]:I D[13]:I D[14]:I D[15]:I Q[8]:O Q[9]:O
*.pininfo Q[10]:O Q[11]:O Q[12]:O Q[13]:O Q[14]:O Q[15]:O TBWM[8]:I TBWM[9]:I
*.pininfo TBWM[10]:I TBWM[11]:I TBWM[12]:I TBWM[13]:I TBWM[14]:I TBWM[15]:I
*.pininfo TD[8]:I TD[9]:I TD[10]:I TD[11]:I TD[12]:I TD[13]:I TD[14]:I
*.pininfo TD[15]:I Q_RED:O GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B
*.pininfo GBW[13]:B GBW[14]:B GBW[15]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B
*.pininfo GD[12]:B GD[13]:B GD[14]:B GD[15]:B GRD0[32]:B GRD0[33]:B
*.pininfo GRD0[34]:B GRD0[35]:B GRD0[36]:B GRD0[37]:B GRD0[38]:B GRD0[39]:B
*.pininfo GRD0[40]:B GRD0[41]:B GRD0[42]:B GRD0[43]:B GRD0[44]:B GRD0[45]:B
*.pininfo GRD0[46]:B GRD0[47]:B GRD0[48]:B GRD0[49]:B GRD0[50]:B GRD0[51]:B
*.pininfo GRD0[52]:B GRD0[53]:B GRD0[54]:B GRD0[55]:B GRD0[56]:B GRD0[57]:B
*.pininfo GRD0[58]:B GRD0[59]:B GRD0[60]:B GRD0[61]:B GRD0[62]:B GRD0[63]:B
*.pininfo GRD1[32]:B GRD1[33]:B GRD1[34]:B GRD1[35]:B GRD1[36]:B GRD1[37]:B
*.pininfo GRD1[38]:B GRD1[39]:B GRD1[40]:B GRD1[41]:B GRD1[42]:B GRD1[43]:B
*.pininfo GRD1[44]:B GRD1[45]:B GRD1[46]:B GRD1[47]:B GRD1[48]:B GRD1[49]:B
*.pininfo GRD1[50]:B GRD1[51]:B GRD1[52]:B GRD1[53]:B GRD1[54]:B GRD1[55]:B
*.pininfo GRD1[56]:B GRD1[57]:B GRD1[58]:B GRD1[59]:B GRD1[60]:B GRD1[61]:B
*.pininfo GRD1[62]:B GRD1[63]:B GRD2[32]:B GRD2[33]:B GRD2[34]:B GRD2[35]:B
*.pininfo GRD2[36]:B GRD2[37]:B GRD2[38]:B GRD2[39]:B GRD2[40]:B GRD2[41]:B
*.pininfo GRD2[42]:B GRD2[43]:B GRD2[44]:B GRD2[45]:B GRD2[46]:B GRD2[47]:B
*.pininfo GRD2[48]:B GRD2[49]:B GRD2[50]:B GRD2[51]:B GRD2[52]:B GRD2[53]:B
*.pininfo GRD2[54]:B GRD2[55]:B GRD2[56]:B GRD2[57]:B GRD2[58]:B GRD2[59]:B
*.pininfo GRD2[60]:B GRD2[61]:B GRD2[62]:B GRD2[63]:B GRD3[32]:B GRD3[33]:B
*.pininfo GRD3[34]:B GRD3[35]:B GRD3[36]:B GRD3[37]:B GRD3[38]:B GRD3[39]:B
*.pininfo GRD3[40]:B GRD3[41]:B GRD3[42]:B GRD3[43]:B GRD3[44]:B GRD3[45]:B
*.pininfo GRD3[46]:B GRD3[47]:B GRD3[48]:B GRD3[49]:B GRD3[50]:B GRD3[51]:B
*.pininfo GRD3[52]:B GRD3[53]:B GRD3[54]:B GRD3[55]:B GRD3[56]:B GRD3[57]:B
*.pininfo GRD3[58]:B GRD3[59]:B GRD3[60]:B GRD3[61]:B GRD3[62]:B GRD3[63]:B
*.pininfo RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B
*.pininfo RGRD1[2]:B RGRD1[3]:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B
*.pininfo RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B RGBW:B RGD:B
XXspram_4096x16m16b1pm2re1GLBIO_GLBIO_R_0 BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] VSS VDDA
+ GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2]
+ GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4]
+ GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] PWR CSC[0]
+ CSC[1] CSC[2] CSC[3] RPFEED[0] RPFEED[1] LCLKIOC TEC SWTC RPINC PREOUTC
+ DBR0C BWBR0C spram_4096x16m16b1pm2re1GLBIO_GLBIO_R m=1
XXspram_4096x16m16b1pm2re1GLBIO_GLBCEN_0 BPUI SPUI AWT VDDA VSS LVTEST VSB400
+ VSB300 VSB200 VSB100 RA WM[0] WM[1] WM[2] RM[0] RM[1] RM[2] BISTE TCLK CLK
+ TWE WE TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8] TA[9] TA[10]
+ TA[11] A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10] A[11] TCE CE
+ SD HN SL SZ PWR EN ENB RMO[0] RMO[1] RMO[2] WMO[0] WMO[1] WMO[2] ag_ctrl
+ T0EN ZRR CSH_RR CSH_LD CSH_ENB RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] VSB[1] VSB[2] VSB[3] VSB[4] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+ QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] GRST LCLKIOC TEC SWTC RPINC PREOUTC
+ DBR0C BWBR0C CSC[0] CSC[1] CSC[2] CSC[3] BSC[0] BSC[1] BSC[2] BSC[3]
+ spram_4096x16m16b1pm2re1GLBIO_GLBCEN m=1
XXspram_4096x16m16b1pm2re1GLBIO_GLBIO_L_0 CSC[0] CSC[1] CSC[2] CSC[3]
+ RPFEED[0] RPFEED[1] LCLKIOC TEC SWTC VDDA VSS PWR RPINC PREOUTC DBR0C
+ BWBR0C BADIO[8] BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13] BADIO[14]
+ BADIO[15] BWM[8] BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15]
+ D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12]
+ Q[13] Q[14] Q[15] TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13]
+ TBWM[14] TBWM[15] TD[8] TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15]
+ Q_RED GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8]
+ GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34]
+ GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42]
+ GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50]
+ GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58]
+ GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34]
+ GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42]
+ GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50]
+ GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58]
+ GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34]
+ GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42]
+ GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50]
+ GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58]
+ GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] RGRD0[0] RGRD0[1] RGRD0[2]
+ RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2]
+ RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGBW RGD
+ spram_4096x16m16b1pm2re1GLBIO_GLBIO_L m=1
.ends spram_4096x16m16b1pm2re1GLBIO

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE VSSX PWR
+ LDB[0] LDB[1] LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] BBMX[0] BBMX[1]
+ BBMX[2] BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0] LDT[1] LDT[2] LDT[3]
+ GD[0] GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] SPU BPU VNW VDDA VSS AG SB[1] SB[2]
+ SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1[0]
+ Z1[1] Z1[2] Z1[3] Z2[0] Z2[1] Z2[2] Z2[3] BBR[0] BBR[1] BBR[2] BBR[3]
+ BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13]
+ BBR[14] BBR[15] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7]
+ BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] RBS[0] RBS[1]
+ RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
*.pininfo VSSX:B PWR:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B BBMX[0]:B BBMX[1]:B BBMX[2]:B
*.pininfo BBMX[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LDT[0]:B LDT[1]:B
*.pininfo LDT[2]:B LDT[3]:B GD[0]:B GBW[0]:B BTMX[0]:B BTMX[1]:B BTMX[2]:B
*.pininfo BTMX[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B SPU:B BPU:B VNW:B VDDA:B VSS:B AG:B
*.pininfo SB[1]:B SB[2]:B SB[3]:B SB[4]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B
*.pininfo SAET:B WM[0]:B WM[1]:B WM[2]:B BSTB:B SAPR:B Z1[0]:B Z1[1]:B
*.pininfo Z1[2]:B Z1[3]:B Z2[0]:B Z2[1]:B Z2[2]:B Z2[3]:B BBR[0]:B BBR[1]:B
*.pininfo BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B BBR[8]:B
*.pininfo BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B
*.pininfo BBR[15]:B BTR[0]:B BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B
*.pininfo BTR[6]:B BTR[7]:B BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B
*.pininfo BTR[13]:B BTR[14]:B BTR[15]:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B
*.pininfo WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B
XXc0r0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BPU BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SPU VDDA VNW
+ VSS VSSX lio_pg16 m=1
XXc1r0 AG BBMX[0] BBMX[1] BBMX[2] BBMX[3] BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SB[1] SB[2]
+ SB[3] SB[4] VDDA VNW VSS VSSX lio_sb16_64 m=1
XXc2r0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BSTB BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ CS[0] CS[1] CS[2] CS[3] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2]
+ LDT[3] GRD0[0] GRD1[0] GRD2[0] GRD3[0] PWR SAET SAPR VDDA VNW VSS VSSX
+ WM[0] WM[1] WM[2] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1] Z2[2] Z2[3] Z2[0]
+ Z2[1] Z2[2] Z2[3] cache4_lio_64 m=1
XXc3r0 BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9]
+ BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBMX[0] BBMX[1] BBMX[2]
+ BBMX[3] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8]
+ BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTMX[0] BTMX[1]
+ BTMX[2] BTMX[3] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR
+ RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1] WBS[2] WBS[3]
+ lmx_cm4x4 m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY VSSX PWR LDB[0]
+ LDB[1] LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] BBMX[0] BBMX[1]
+ BBMX[2] BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0] LDT[1] LDT[2] LDT[3]
+ GD[0] GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4]
+ BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14]
+ BBR[15] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8]
+ BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] SPU BPU AG SB[1]
+ SB[2] SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] VDDA VSS WBS[0] WBS[1]
+ WBS[2] WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR
+ LDB[4] LDB[5] LDB[6] LDB[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] BBMX[4] BBMX[5]
+ BBMX[6] BBMX[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7] LDT[4] LDT[5] LDT[6] LDT[7]
+ GD[1] GBW[1] BTMX[4] BTMX[5] BTMX[6] BTMX[7] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD0[4] GRD0[5] GRD0[6] GRD0[7] BBR[16] BBR[17] BBR[18] BBR[19]
+ BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27] BBR[28]
+ BBR[29] BBR[30] BBR[31] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21]
+ BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30]
+ BTR[31] LDB[8] LDB[9] LDB[10] LDB[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ BBMX[8] BBMX[9] BBMX[10] BBMX[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] LDT[8]
+ LDT[9] LDT[10] LDT[11] GD[2] GBW[2] BTMX[8] BTMX[9] BTMX[10] BTMX[11]
+ GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD0[8] GRD0[9] GRD0[10] GRD0[11] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BTR[32] BTR[33] BTR[34]
+ BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43]
+ BTR[44] BTR[45] BTR[46] BTR[47] LDB[12] LDB[13] LDB[14] LDB[15] GRD2[12]
+ GRD2[13] GRD2[14] GRD2[15] BBMX[12] BBMX[13] BBMX[14] BBMX[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] LDT[12] LDT[13] LDT[14] LDT[15] GD[3] GBW[3]
+ BTMX[12] BTMX[13] BTMX[14] BTMX[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52]
+ BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61]
+ BBR[62] BBR[63] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ LDB[16] LDB[17] LDB[18] LDB[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19]
+ BBMX[16] BBMX[17] BBMX[18] BBMX[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ LDT[16] LDT[17] LDT[18] LDT[19] GD[4] GBW[4] BTMX[16] BTMX[17] BTMX[18]
+ BTMX[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71]
+ BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] LDB[20] LDB[21] LDB[22]
+ LDB[23] GRD2[20] GRD2[21] GRD2[22] GRD2[23] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] LDT[20] LDT[21] LDT[22]
+ LDT[23] GD[5] GBW[5] BTMX[20] BTMX[21] BTMX[22] BTMX[23] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD0[20] GRD0[21] GRD0[22] GRD0[23] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BTR[80] BTR[81] BTR[82] BTR[83]
+ BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92]
+ BTR[93] BTR[94] BTR[95] LDB[24] LDB[25] LDB[26] LDB[27] GRD2[24] GRD2[25]
+ GRD2[26] GRD2[27] BBMX[24] BBMX[25] BBMX[26] BBMX[27] GRD3[24] GRD3[25]
+ GRD3[26] GRD3[27] LDT[24] LDT[25] LDT[26] LDT[27] GD[6] GBW[6] BTMX[24]
+ BTMX[25] BTMX[26] BTMX[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] BBR[96] BBR[97] BBR[98] BBR[99] BBR[100]
+ BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107] BBR[108]
+ BBR[109] BBR[110] BBR[111] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] LDB[28] LDB[29] LDB[30] LDB[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] BBMX[28] BBMX[29] BBMX[30] BBMX[31] GRD3[28]
+ GRD3[29] GRD3[30] GRD3[31] LDT[28] LDT[29] LDT[30] LDT[31] GD[7] GBW[7]
+ BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1]
+ Z2[2] Z2[3]
*.pininfo VSSX:B PWR:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B BBMX[0]:B BBMX[1]:B BBMX[2]:B
*.pininfo BBMX[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LDT[0]:B LDT[1]:B
*.pininfo LDT[2]:B LDT[3]:B GD[0]:B GBW[0]:B BTMX[0]:B BTMX[1]:B BTMX[2]:B
*.pininfo BTMX[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B BBR[0]:B BBR[1]:B BBR[2]:B BBR[3]:B
*.pininfo BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B BBR[8]:B BBR[9]:B BBR[10]:B
*.pininfo BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B BBR[15]:B BTR[0]:B BTR[1]:B
*.pininfo BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B BTR[7]:B BTR[8]:B
*.pininfo BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B BTR[14]:B
*.pininfo BTR[15]:B SPU:B BPU:B AG:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B VNW:B
*.pininfo RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B VDDA:B VSS:B WBS[0]:B WBS[1]:B
*.pininfo WBS[2]:B WBS[3]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B WM[0]:B WM[1]:B
*.pininfo WM[2]:B SAET:B BSTB:B SAPR:B LDB[4]:B LDB[5]:B LDB[6]:B LDB[7]:B
*.pininfo GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B
*.pininfo LDT[4]:B LDT[5]:B LDT[6]:B LDT[7]:B GD[1]:B GBW[1]:B BTMX[4]:B
*.pininfo BTMX[5]:B BTMX[6]:B BTMX[7]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B BBR[16]:B
*.pininfo BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B BBR[21]:B BBR[22]:B
*.pininfo BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B BBR[27]:B BBR[28]:B
*.pininfo BBR[29]:B BBR[30]:B BBR[31]:B BTR[16]:B BTR[17]:B BTR[18]:B
*.pininfo BTR[19]:B BTR[20]:B BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B
*.pininfo BTR[25]:B BTR[26]:B BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B
*.pininfo BTR[31]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B GRD2[8]:B GRD2[9]:B
*.pininfo GRD2[10]:B GRD2[11]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B LDT[8]:B LDT[9]:B
*.pininfo LDT[10]:B LDT[11]:B GD[2]:B GBW[2]:B BTMX[8]:B BTMX[9]:B BTMX[10]:B
*.pininfo BTMX[11]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B BBR[32]:B BBR[33]:B BBR[34]:B
*.pininfo BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B BBR[39]:B BBR[40]:B
*.pininfo BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B BBR[45]:B BBR[46]:B
*.pininfo BBR[47]:B BTR[32]:B BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B
*.pininfo BTR[37]:B BTR[38]:B BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B
*.pininfo BTR[43]:B BTR[44]:B BTR[45]:B BTR[46]:B BTR[47]:B LDB[12]:B
*.pininfo LDB[13]:B LDB[14]:B LDB[15]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B
*.pininfo GRD2[15]:B BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B GRD3[12]:B
*.pininfo GRD3[13]:B GRD3[14]:B GRD3[15]:B LDT[12]:B LDT[13]:B LDT[14]:B
*.pininfo LDT[15]:B GD[3]:B GBW[3]:B BTMX[12]:B BTMX[13]:B BTMX[14]:B
*.pininfo BTMX[15]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD0[12]:B
*.pininfo GRD0[13]:B GRD0[14]:B GRD0[15]:B BBR[48]:B BBR[49]:B BBR[50]:B
*.pininfo BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B
*.pininfo BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B
*.pininfo BBR[63]:B BTR[48]:B BTR[49]:B BTR[50]:B BTR[51]:B BTR[52]:B
*.pininfo BTR[53]:B BTR[54]:B BTR[55]:B BTR[56]:B BTR[57]:B BTR[58]:B
*.pininfo BTR[59]:B BTR[60]:B BTR[61]:B BTR[62]:B BTR[63]:B LDB[16]:B
*.pininfo LDB[17]:B LDB[18]:B LDB[19]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B BBMX[16]:B BBMX[17]:B BBMX[18]:B BBMX[19]:B GRD3[16]:B
*.pininfo GRD3[17]:B GRD3[18]:B GRD3[19]:B LDT[16]:B LDT[17]:B LDT[18]:B
*.pininfo LDT[19]:B GD[4]:B GBW[4]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B
*.pininfo BTMX[19]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD0[16]:B
*.pininfo GRD0[17]:B GRD0[18]:B GRD0[19]:B BBR[64]:B BBR[65]:B BBR[66]:B
*.pininfo BBR[67]:B BBR[68]:B BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B
*.pininfo BBR[73]:B BBR[74]:B BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B
*.pininfo BBR[79]:B BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B BTR[68]:B
*.pininfo BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B BTR[74]:B
*.pininfo BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B LDB[20]:B
*.pininfo LDB[21]:B LDB[22]:B LDB[23]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B LDT[20]:B LDT[21]:B LDT[22]:B
*.pininfo LDT[23]:B GD[5]:B GBW[5]:B BTMX[20]:B BTMX[21]:B BTMX[22]:B
*.pininfo BTMX[23]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B BBR[80]:B BBR[81]:B BBR[82]:B
*.pininfo BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B BBR[87]:B BBR[88]:B
*.pininfo BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B BBR[93]:B BBR[94]:B
*.pininfo BBR[95]:B BTR[80]:B BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B
*.pininfo BTR[85]:B BTR[86]:B BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B
*.pininfo BTR[91]:B BTR[92]:B BTR[93]:B BTR[94]:B BTR[95]:B LDB[24]:B
*.pininfo LDB[25]:B LDB[26]:B LDB[27]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B
*.pininfo GRD2[27]:B BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B LDT[24]:B LDT[25]:B LDT[26]:B
*.pininfo LDT[27]:B GD[6]:B GBW[6]:B BTMX[24]:B BTMX[25]:B BTMX[26]:B
*.pininfo BTMX[27]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B BBR[96]:B BBR[97]:B BBR[98]:B
*.pininfo BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B
*.pininfo BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B
*.pininfo BBR[111]:B BTR[96]:B BTR[97]:B BTR[98]:B BTR[99]:B BTR[100]:B
*.pininfo BTR[101]:B BTR[102]:B BTR[103]:B BTR[104]:B BTR[105]:B BTR[106]:B
*.pininfo BTR[107]:B BTR[108]:B BTR[109]:B BTR[110]:B BTR[111]:B LDB[28]:B
*.pininfo LDB[29]:B LDB[30]:B LDB[31]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B
*.pininfo GRD2[31]:B BBMX[28]:B BBMX[29]:B BBMX[30]:B BBMX[31]:B GRD3[28]:B
*.pininfo GRD3[29]:B GRD3[30]:B GRD3[31]:B LDT[28]:B LDT[29]:B LDT[30]:B
*.pininfo LDT[31]:B GD[7]:B GBW[7]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B
*.pininfo BTMX[31]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD0[28]:B
*.pininfo GRD0[29]:B GRD0[30]:B GRD0[31]:B BBR[112]:B BBR[113]:B BBR[114]:B
*.pininfo BBR[115]:B BBR[116]:B BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B
*.pininfo BBR[121]:B BBR[122]:B BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B
*.pininfo BBR[127]:B BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B BTR[116]:B
*.pininfo BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B BTR[122]:B
*.pininfo BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B Z1[0]:B
*.pininfo Z1[1]:B Z1[2]:B Z1[3]:B Z2[0]:B Z2[1]:B Z2[2]:B Z2[3]:B
XX00 VSSX PWR LDB[0] LDB[1] LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3]
+ BBMX[0] BBMX[1] BBMX[2] BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0]
+ LDT[1] LDT[2] LDT[3] GD[0] GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] SPU BPU VNW VDDA
+ VSS AG SB[1] SB[2] SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0] WM[1]
+ WM[2] BSTB SAPR Z1_0[0] Z1_0[1] Z1_0[2] Z1_0[3] Z2_0[0] Z2_0[1] Z2_0[2]
+ Z2_0[3] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8]
+ BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BTR[0] BTR[1] BTR[2]
+ BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12]
+ BTR[13] BTR[14] BTR[15] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2]
+ WBS[3] spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
XX01 VSSX PWR LDB[4] LDB[5] LDB[6] LDB[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ BBMX[4] BBMX[5] BBMX[6] BBMX[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7] LDT[4]
+ LDT[5] LDT[6] LDT[7] GD[1] GBW[1] BTMX[4] BTMX[5] BTMX[6] BTMX[7] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD0[4] GRD0[5] GRD0[6] GRD0[7] SPU BPU VNW VDDA
+ VSS AG SB[1] SB[2] SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0] WM[1]
+ WM[2] BSTB SAPR Z1_1[0] Z1_1[1] Z1_1[2] Z1_1[3] Z2_1[0] Z2_1[1] Z2_1[2]
+ Z2_1[3] BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23]
+ BBR[24] BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BTR[16]
+ BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25]
+ BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31] RBS[0] RBS[1] RBS[2] RBS[3]
+ WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
XX02 VSSX PWR LDB[8] LDB[9] LDB[10] LDB[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ BBMX[8] BBMX[9] BBMX[10] BBMX[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] LDT[8]
+ LDT[9] LDT[10] LDT[11] GD[2] GBW[2] BTMX[8] BTMX[9] BTMX[10] BTMX[11]
+ GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD0[8] GRD0[9] GRD0[10] GRD0[11] SPU BPU
+ VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0]
+ WM[1] WM[2] BSTB SAPR Z1_2[0] Z1_2[1] Z1_2[2] Z1_2[3] Z2_2[0] Z2_2[1]
+ Z2_2[2] Z2_2[3] BBR[32] BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38]
+ BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47]
+ BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40]
+ BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] RBS[0] RBS[1]
+ RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
XX03 VSSX PWR LDB[12] LDB[13] LDB[14] LDB[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] BBMX[12] BBMX[13] BBMX[14] BBMX[15] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] LDT[12] LDT[13] LDT[14] LDT[15] GD[3] GBW[3] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_3[0] Z1_3[1] Z1_3[2]
+ Z1_3[3] Z2_3[0] Z2_3[1] Z2_3[2] Z2_3[3] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53]
+ BTR[54] BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62]
+ BTR[63] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
XX04 VSSX PWR LDB[16] LDB[17] LDB[18] LDB[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] BBMX[16] BBMX[17] BBMX[18] BBMX[19] GRD3[16] GRD3[17] GRD3[18]
+ GRD3[19] LDT[16] LDT[17] LDT[18] LDT[19] GD[4] GBW[4] BTMX[16] BTMX[17]
+ BTMX[18] BTMX[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD0[16] GRD0[17]
+ GRD0[18] GRD0[19] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_4[0] Z1_4[1] Z1_4[2]
+ Z1_4[3] Z2_4[0] Z2_4[1] Z2_4[2] Z2_4[3] BBR[64] BBR[65] BBR[66] BBR[67]
+ BBR[68] BBR[69] BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76]
+ BBR[77] BBR[78] BBR[79] BTR[64] BTR[65] BTR[66] BTR[67] BTR[68] BTR[69]
+ BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76] BTR[77] BTR[78]
+ BTR[79] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
XX05 VSSX PWR LDB[20] LDB[21] LDB[22] LDB[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] BBMX[20] BBMX[21] BBMX[22] BBMX[23] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] LDT[20] LDT[21] LDT[22] LDT[23] GD[5] GBW[5] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_5[0] Z1_5[1] Z1_5[2]
+ Z1_5[3] Z2_5[0] Z2_5[1] Z2_5[2] Z2_5[3] BBR[80] BBR[81] BBR[82] BBR[83]
+ BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90] BBR[91] BBR[92]
+ BBR[93] BBR[94] BBR[95] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85]
+ BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94]
+ BTR[95] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
XX06 VSSX PWR LDB[24] LDB[25] LDB[26] LDB[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] BBMX[24] BBMX[25] BBMX[26] BBMX[27] GRD3[24] GRD3[25] GRD3[26]
+ GRD3[27] LDT[24] LDT[25] LDT[26] LDT[27] GD[6] GBW[6] BTMX[24] BTMX[25]
+ BTMX[26] BTMX[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD0[24] GRD0[25]
+ GRD0[26] GRD0[27] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_6[0] Z1_6[1] Z1_6[2]
+ Z1_6[3] Z2_6[0] Z2_6[1] Z2_6[2] Z2_6[3] BBR[96] BBR[97] BBR[98] BBR[99]
+ BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107]
+ BBR[108] BBR[109] BBR[110] BBR[111] BTR[96] BTR[97] BTR[98] BTR[99]
+ BTR[100] BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107]
+ BTR[108] BTR[109] BTR[110] BTR[111] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0]
+ WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
XX07 VSSX PWR LDB[28] LDB[29] LDB[30] LDB[31] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] BBMX[28] BBMX[29] BBMX[30] BBMX[31] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] LDT[28] LDT[29] LDT[30] LDT[31] GD[7] GBW[7] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1[0] Z1[1] Z1[2] Z1[3]
+ Z2[0] Z2[1] Z2[2] Z2[3] BBR[112] BBR[113] BBR[114] BBR[115] BBR[116]
+ BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123] BBR[124]
+ BBR[125] BBR[126] BBR[127] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2]
+ WBS[3] spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_SLICE m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA PWR VDDA VSS SPU BPU AG
+ SB[1] SB[2] SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1]
+ WBS[2] WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR VSSX
+ LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9]
+ LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18]
+ LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27]
+ LDB[28] LDB[29] LDB[30] LDB[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6]
+ BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13] BBMX[14]
+ BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29] BBMX[30]
+ BBMX[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9]
+ LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18]
+ LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27]
+ LDT[28] LDT[29] LDT[30] LDT[31] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6]
+ GD[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] BTMX[0]
+ BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9]
+ BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16] BTMX[17]
+ BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24] BTMX[25]
+ BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10]
+ GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26]
+ GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4]
+ BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14]
+ BBR[15] BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23]
+ BBR[24] BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50]
+ BBR[51] BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59]
+ BBR[60] BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68]
+ BBR[69] BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77]
+ BBR[78] BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86]
+ BBR[87] BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95]
+ BBR[96] BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103]
+ BBR[104] BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111]
+ BBR[112] BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119]
+ BBR[120] BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127]
+ BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9]
+ BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18]
+ BTR[19] BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27]
+ BTR[28] BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36]
+ BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45]
+ BTR[46] BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ BTR[64] BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72]
+ BTR[73] BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81]
+ BTR[82] BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90]
+ BTR[91] BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99]
+ BTR[100] BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107]
+ BTR[108] BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127]
*.pininfo PWR:B VDDA:B VSS:B SPU:B BPU:B AG:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B
*.pininfo VNW:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B WBS[0]:B WBS[1]:B
*.pininfo WBS[2]:B WBS[3]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B WM[0]:B WM[1]:B
*.pininfo WM[2]:B SAET:B BSTB:B SAPR:B VSSX:B LDB[0]:B LDB[1]:B LDB[2]:B
*.pininfo LDB[3]:B LDB[4]:B LDB[5]:B LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B
*.pininfo LDB[10]:B LDB[11]:B LDB[12]:B LDB[13]:B LDB[14]:B LDB[15]:B
*.pininfo LDB[16]:B LDB[17]:B LDB[18]:B LDB[19]:B LDB[20]:B LDB[21]:B
*.pininfo LDB[22]:B LDB[23]:B LDB[24]:B LDB[25]:B LDB[26]:B LDB[27]:B
*.pininfo LDB[28]:B LDB[29]:B LDB[30]:B LDB[31]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B
*.pininfo GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B
*.pininfo GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B
*.pininfo GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B
*.pininfo BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B BBMX[16]:B BBMX[17]:B
*.pininfo BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B
*.pininfo BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B BBMX[28]:B BBMX[29]:B
*.pininfo BBMX[30]:B BBMX[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B
*.pininfo GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B GRD3[9]:B
*.pininfo GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B
*.pininfo GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B GRD3[21]:B
*.pininfo GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B GRD3[27]:B
*.pininfo GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B LDT[0]:B LDT[1]:B
*.pininfo LDT[2]:B LDT[3]:B LDT[4]:B LDT[5]:B LDT[6]:B LDT[7]:B LDT[8]:B
*.pininfo LDT[9]:B LDT[10]:B LDT[11]:B LDT[12]:B LDT[13]:B LDT[14]:B
*.pininfo LDT[15]:B LDT[16]:B LDT[17]:B LDT[18]:B LDT[19]:B LDT[20]:B
*.pininfo LDT[21]:B LDT[22]:B LDT[23]:B LDT[24]:B LDT[25]:B LDT[26]:B
*.pininfo LDT[27]:B LDT[28]:B LDT[29]:B LDT[30]:B LDT[31]:B GD[0]:B GD[1]:B
*.pininfo GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GBW[0]:B GBW[1]:B
*.pininfo GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B BTMX[0]:B
*.pininfo BTMX[1]:B BTMX[2]:B BTMX[3]:B BTMX[4]:B BTMX[5]:B BTMX[6]:B
*.pininfo BTMX[7]:B BTMX[8]:B BTMX[9]:B BTMX[10]:B BTMX[11]:B BTMX[12]:B
*.pininfo BTMX[13]:B BTMX[14]:B BTMX[15]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B
*.pininfo BTMX[19]:B BTMX[20]:B BTMX[21]:B BTMX[22]:B BTMX[23]:B BTMX[24]:B
*.pininfo BTMX[25]:B BTMX[26]:B BTMX[27]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B
*.pininfo BTMX[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B BBR[0]:B
*.pininfo BBR[1]:B BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B
*.pininfo BBR[8]:B BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B
*.pininfo BBR[15]:B BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B
*.pininfo BBR[21]:B BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B
*.pininfo BBR[27]:B BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B BBR[32]:B
*.pininfo BBR[33]:B BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B
*.pininfo BBR[39]:B BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B
*.pininfo BBR[45]:B BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B BBR[50]:B
*.pininfo BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B
*.pininfo BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B
*.pininfo BBR[63]:B BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B BBR[68]:B
*.pininfo BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B BBR[74]:B
*.pininfo BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B BBR[80]:B
*.pininfo BBR[81]:B BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B
*.pininfo BBR[87]:B BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B
*.pininfo BBR[93]:B BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B BBR[98]:B
*.pininfo BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B
*.pininfo BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B
*.pininfo BBR[111]:B BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B BBR[116]:B
*.pininfo BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B BBR[122]:B
*.pininfo BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B BTR[0]:B
*.pininfo BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B BTR[7]:B
*.pininfo BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B BTR[14]:B
*.pininfo BTR[15]:B BTR[16]:B BTR[17]:B BTR[18]:B BTR[19]:B BTR[20]:B
*.pininfo BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B BTR[25]:B BTR[26]:B
*.pininfo BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B BTR[31]:B BTR[32]:B
*.pininfo BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B BTR[37]:B BTR[38]:B
*.pininfo BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B BTR[43]:B BTR[44]:B
*.pininfo BTR[45]:B BTR[46]:B BTR[47]:B BTR[48]:B BTR[49]:B BTR[50]:B
*.pininfo BTR[51]:B BTR[52]:B BTR[53]:B BTR[54]:B BTR[55]:B BTR[56]:B
*.pininfo BTR[57]:B BTR[58]:B BTR[59]:B BTR[60]:B BTR[61]:B BTR[62]:B
*.pininfo BTR[63]:B BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B BTR[68]:B
*.pininfo BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B BTR[74]:B
*.pininfo BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B BTR[80]:B
*.pininfo BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B BTR[85]:B BTR[86]:B
*.pininfo BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B BTR[91]:B BTR[92]:B
*.pininfo BTR[93]:B BTR[94]:B BTR[95]:B BTR[96]:B BTR[97]:B BTR[98]:B
*.pininfo BTR[99]:B BTR[100]:B BTR[101]:B BTR[102]:B BTR[103]:B BTR[104]:B
*.pininfo BTR[105]:B BTR[106]:B BTR[107]:B BTR[108]:B BTR[109]:B BTR[110]:B
*.pininfo BTR[111]:B BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B BTR[116]:B
*.pininfo BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B BTR[122]:B
*.pininfo BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B
XXspram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY_0_R VSSX PWR LDB[0] LDB[1]
+ LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] BBMX[0] BBMX[1] BBMX[2]
+ BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0] LDT[1] LDT[2] LDT[3] GD[0]
+ GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5]
+ BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9]
+ BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] SPU BPU AG SB[1] SB[2]
+ SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] VDDA VSS WBS[0] WBS[1] WBS[2]
+ WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR LDB[4]
+ LDB[5] LDB[6] LDB[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] BBMX[4] BBMX[5]
+ BBMX[6] BBMX[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7] LDT[4] LDT[5] LDT[6] LDT[7]
+ GD[1] GBW[1] BTMX[4] BTMX[5] BTMX[6] BTMX[7] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD0[4] GRD0[5] GRD0[6] GRD0[7] BBR[16] BBR[17] BBR[18] BBR[19]
+ BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27] BBR[28]
+ BBR[29] BBR[30] BBR[31] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21]
+ BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30]
+ BTR[31] LDB[8] LDB[9] LDB[10] LDB[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ BBMX[8] BBMX[9] BBMX[10] BBMX[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] LDT[8]
+ LDT[9] LDT[10] LDT[11] GD[2] GBW[2] BTMX[8] BTMX[9] BTMX[10] BTMX[11]
+ GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD0[8] GRD0[9] GRD0[10] GRD0[11] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BTR[32] BTR[33] BTR[34]
+ BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43]
+ BTR[44] BTR[45] BTR[46] BTR[47] LDB[12] LDB[13] LDB[14] LDB[15] GRD2[12]
+ GRD2[13] GRD2[14] GRD2[15] BBMX[12] BBMX[13] BBMX[14] BBMX[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] LDT[12] LDT[13] LDT[14] LDT[15] GD[3] GBW[3]
+ BTMX[12] BTMX[13] BTMX[14] BTMX[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52]
+ BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61]
+ BBR[62] BBR[63] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ LDB[16] LDB[17] LDB[18] LDB[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19]
+ BBMX[16] BBMX[17] BBMX[18] BBMX[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ LDT[16] LDT[17] LDT[18] LDT[19] GD[4] GBW[4] BTMX[16] BTMX[17] BTMX[18]
+ BTMX[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71]
+ BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] LDB[20] LDB[21] LDB[22]
+ LDB[23] GRD2[20] GRD2[21] GRD2[22] GRD2[23] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] LDT[20] LDT[21] LDT[22]
+ LDT[23] GD[5] GBW[5] BTMX[20] BTMX[21] BTMX[22] BTMX[23] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD0[20] GRD0[21] GRD0[22] GRD0[23] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BTR[80] BTR[81] BTR[82] BTR[83]
+ BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92]
+ BTR[93] BTR[94] BTR[95] LDB[24] LDB[25] LDB[26] LDB[27] GRD2[24] GRD2[25]
+ GRD2[26] GRD2[27] BBMX[24] BBMX[25] BBMX[26] BBMX[27] GRD3[24] GRD3[25]
+ GRD3[26] GRD3[27] LDT[24] LDT[25] LDT[26] LDT[27] GD[6] GBW[6] BTMX[24]
+ BTMX[25] BTMX[26] BTMX[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] BBR[96] BBR[97] BBR[98] BBR[99] BBR[100]
+ BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107] BBR[108]
+ BBR[109] BBR[110] BBR[111] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] LDB[28] LDB[29] LDB[30] LDB[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] BBMX[28] BBMX[29] BBMX[30] BBMX[31] GRD3[28]
+ GRD3[29] GRD3[30] GRD3[31] LDT[28] LDT[29] LDT[30] LDT[31] GD[7] GBW[7]
+ BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1]
+ Z2[2] Z2[3] spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_LIOARY m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARR VSS VDDA PWR CS[0] CS[1] CS[2]
+ CS[3] RBS[0] RBS[1] RBS[2] RBS[3] SB[1] SB[2] SB[3] SB[4] WBS[0] WBS[1]
+ WBS[2] WBS[3] WM[0] WM[1] WM[2] SPU BPU AG VNW SAET BSTB SAPR BBMX[0]
+ BBMX[1] BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9]
+ BBMX[10] BBMX[11] BBMX[12] BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17]
+ BBMX[18] BBMX[19] BBMX[20] BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25]
+ BBMX[26] BBMX[27] BBMX[28] BBMX[29] BBMX[30] BBMX[31] BTMX[0] BTMX[1]
+ BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10]
+ BTMX[11] BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18]
+ BTMX[19] BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26]
+ BTMX[27] BTMX[28] BTMX[29] BTMX[30] BTMX[31] GBW[0] GBW[1] GBW[2] GBW[3]
+ GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16]
+ GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9]
+ GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17]
+ GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25]
+ GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1]
+ GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10]
+ GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11]
+ GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27]
+ GRD3[28] GRD3[29] GRD3[30] GRD3[31] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4]
+ LDB[5] LDB[6] LDB[7] LDB[8] LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14]
+ LDB[15] LDB[16] LDB[17] LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23]
+ LDB[24] LDB[25] LDB[26] LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDT[0]
+ LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9] LDT[10]
+ LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18] LDT[19]
+ LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27] LDT[28]
+ LDT[29] LDT[30] LDT[31] VSSX BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5]
+ BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24]
+ BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33]
+ BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42]
+ BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69]
+ BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78]
+ BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87]
+ BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96]
+ BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104]
+ BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112]
+ BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120]
+ BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BTR[0]
+ BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10]
+ BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19]
+ BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28]
+ BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37]
+ BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46]
+ BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55]
+ BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82]
+ BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91]
+ BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127]
*.pininfo VSS:B VDDA:B PWR:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B RBS[0]:B
*.pininfo RBS[1]:B RBS[2]:B RBS[3]:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B WBS[0]:B
*.pininfo WBS[1]:B WBS[2]:B WBS[3]:B WM[0]:B WM[1]:B WM[2]:B SPU:B BPU:B AG:B
*.pininfo VNW:B SAET:B BSTB:B SAPR:B BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B
*.pininfo BBMX[4]:B BBMX[5]:B BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B
*.pininfo BBMX[10]:B BBMX[11]:B BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B
*.pininfo BBMX[16]:B BBMX[17]:B BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B
*.pininfo BBMX[22]:B BBMX[23]:B BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B
*.pininfo BBMX[28]:B BBMX[29]:B BBMX[30]:B BBMX[31]:B BTMX[0]:B BTMX[1]:B
*.pininfo BTMX[2]:B BTMX[3]:B BTMX[4]:B BTMX[5]:B BTMX[6]:B BTMX[7]:B
*.pininfo BTMX[8]:B BTMX[9]:B BTMX[10]:B BTMX[11]:B BTMX[12]:B BTMX[13]:B
*.pininfo BTMX[14]:B BTMX[15]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B BTMX[19]:B
*.pininfo BTMX[20]:B BTMX[21]:B BTMX[22]:B BTMX[23]:B BTMX[24]:B BTMX[25]:B
*.pininfo BTMX[26]:B BTMX[27]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B BTMX[31]:B
*.pininfo GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B
*.pininfo GBW[7]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B
*.pininfo GD[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B
*.pininfo GRD0[6]:B GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B
*.pininfo GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B
*.pininfo GRD0[18]:B GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B
*.pininfo GRD0[24]:B GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B
*.pininfo GRD0[30]:B GRD0[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B
*.pininfo GRD1[4]:B GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B
*.pininfo GRD1[10]:B GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B
*.pininfo GRD1[16]:B GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B
*.pininfo GRD1[22]:B GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B
*.pininfo GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B
*.pininfo GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B
*.pininfo GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B
*.pininfo GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B
*.pininfo GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B
*.pininfo GRD3[6]:B GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B
*.pininfo GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B
*.pininfo GRD3[18]:B GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B
*.pininfo GRD3[24]:B GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B
*.pininfo GRD3[30]:B GRD3[31]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDB[4]:B
*.pininfo LDB[5]:B LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B
*.pininfo LDB[12]:B LDB[13]:B LDB[14]:B LDB[15]:B LDB[16]:B LDB[17]:B
*.pininfo LDB[18]:B LDB[19]:B LDB[20]:B LDB[21]:B LDB[22]:B LDB[23]:B
*.pininfo LDB[24]:B LDB[25]:B LDB[26]:B LDB[27]:B LDB[28]:B LDB[29]:B
*.pininfo LDB[30]:B LDB[31]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B LDT[4]:B
*.pininfo LDT[5]:B LDT[6]:B LDT[7]:B LDT[8]:B LDT[9]:B LDT[10]:B LDT[11]:B
*.pininfo LDT[12]:B LDT[13]:B LDT[14]:B LDT[15]:B LDT[16]:B LDT[17]:B
*.pininfo LDT[18]:B LDT[19]:B LDT[20]:B LDT[21]:B LDT[22]:B LDT[23]:B
*.pininfo LDT[24]:B LDT[25]:B LDT[26]:B LDT[27]:B LDT[28]:B LDT[29]:B
*.pininfo LDT[30]:B LDT[31]:B VSSX:B BBR[0]:B BBR[1]:B BBR[2]:B BBR[3]:B
*.pininfo BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B BBR[8]:B BBR[9]:B BBR[10]:B
*.pininfo BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B BBR[15]:B BBR[16]:B
*.pininfo BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B BBR[21]:B BBR[22]:B
*.pininfo BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B BBR[27]:B BBR[28]:B
*.pininfo BBR[29]:B BBR[30]:B BBR[31]:B BBR[32]:B BBR[33]:B BBR[34]:B
*.pininfo BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B BBR[39]:B BBR[40]:B
*.pininfo BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B BBR[45]:B BBR[46]:B
*.pininfo BBR[47]:B BBR[48]:B BBR[49]:B BBR[50]:B BBR[51]:B BBR[52]:B
*.pininfo BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B BBR[57]:B BBR[58]:B
*.pininfo BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B BBR[63]:B BBR[64]:B
*.pininfo BBR[65]:B BBR[66]:B BBR[67]:B BBR[68]:B BBR[69]:B BBR[70]:B
*.pininfo BBR[71]:B BBR[72]:B BBR[73]:B BBR[74]:B BBR[75]:B BBR[76]:B
*.pininfo BBR[77]:B BBR[78]:B BBR[79]:B BBR[80]:B BBR[81]:B BBR[82]:B
*.pininfo BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B BBR[87]:B BBR[88]:B
*.pininfo BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B BBR[93]:B BBR[94]:B
*.pininfo BBR[95]:B BBR[96]:B BBR[97]:B BBR[98]:B BBR[99]:B BBR[100]:B
*.pininfo BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B BBR[105]:B BBR[106]:B
*.pininfo BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B BBR[111]:B BBR[112]:B
*.pininfo BBR[113]:B BBR[114]:B BBR[115]:B BBR[116]:B BBR[117]:B BBR[118]:B
*.pininfo BBR[119]:B BBR[120]:B BBR[121]:B BBR[122]:B BBR[123]:B BBR[124]:B
*.pininfo BBR[125]:B BBR[126]:B BBR[127]:B BTR[0]:B BTR[1]:B BTR[2]:B
*.pininfo BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B BTR[7]:B BTR[8]:B BTR[9]:B
*.pininfo BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B BTR[14]:B BTR[15]:B
*.pininfo BTR[16]:B BTR[17]:B BTR[18]:B BTR[19]:B BTR[20]:B BTR[21]:B
*.pininfo BTR[22]:B BTR[23]:B BTR[24]:B BTR[25]:B BTR[26]:B BTR[27]:B
*.pininfo BTR[28]:B BTR[29]:B BTR[30]:B BTR[31]:B BTR[32]:B BTR[33]:B
*.pininfo BTR[34]:B BTR[35]:B BTR[36]:B BTR[37]:B BTR[38]:B BTR[39]:B
*.pininfo BTR[40]:B BTR[41]:B BTR[42]:B BTR[43]:B BTR[44]:B BTR[45]:B
*.pininfo BTR[46]:B BTR[47]:B BTR[48]:B BTR[49]:B BTR[50]:B BTR[51]:B
*.pininfo BTR[52]:B BTR[53]:B BTR[54]:B BTR[55]:B BTR[56]:B BTR[57]:B
*.pininfo BTR[58]:B BTR[59]:B BTR[60]:B BTR[61]:B BTR[62]:B BTR[63]:B
*.pininfo BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B BTR[68]:B BTR[69]:B
*.pininfo BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B BTR[74]:B BTR[75]:B
*.pininfo BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B BTR[80]:B BTR[81]:B
*.pininfo BTR[82]:B BTR[83]:B BTR[84]:B BTR[85]:B BTR[86]:B BTR[87]:B
*.pininfo BTR[88]:B BTR[89]:B BTR[90]:B BTR[91]:B BTR[92]:B BTR[93]:B
*.pininfo BTR[94]:B BTR[95]:B BTR[96]:B BTR[97]:B BTR[98]:B BTR[99]:B
*.pininfo BTR[100]:B BTR[101]:B BTR[102]:B BTR[103]:B BTR[104]:B BTR[105]:B
*.pininfo BTR[106]:B BTR[107]:B BTR[108]:B BTR[109]:B BTR[110]:B BTR[111]:B
*.pininfo BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B BTR[116]:B BTR[117]:B
*.pininfo BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B BTR[122]:B BTR[123]:B
*.pininfo BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B
XXspram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA_0 PWR VDDA VSS SPU BPU AG SB[1]
+ SB[2] SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2]
+ WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR VSSX LDB[0]
+ LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9] LDB[10]
+ LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18] LDB[19]
+ LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27] LDB[28]
+ LDB[29] LDB[30] LDB[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5]
+ GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6]
+ BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13] BBMX[14]
+ BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29] BBMX[30]
+ BBMX[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9]
+ LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18]
+ LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27]
+ LDT[28] LDT[29] LDT[30] LDT[31] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6]
+ GD[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] BTMX[0]
+ BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9]
+ BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16] BTMX[17]
+ BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24] BTMX[25]
+ BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10]
+ GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26]
+ GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4]
+ BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14]
+ BBR[15] BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23]
+ BBR[24] BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50]
+ BBR[51] BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59]
+ BBR[60] BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68]
+ BBR[69] BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77]
+ BBR[78] BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86]
+ BBR[87] BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95]
+ BBR[96] BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103]
+ BBR[104] BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111]
+ BBR[112] BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119]
+ BBR[120] BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127]
+ BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9]
+ BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18]
+ BTR[19] BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27]
+ BTR[28] BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36]
+ BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45]
+ BTR[46] BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ BTR[64] BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72]
+ BTR[73] BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81]
+ BTR[82] BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90]
+ BTR[91] BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99]
+ BTR[100] BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107]
+ BTR[108] BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127]
+ spram_4096x16m16b1pm2re1PM2M16B1ARRARRAYA m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARR

.subckt spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_R BBMX[0] BBMX[1] BBMX[2]
+ BBMX[3] BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11]
+ BBMX[12] BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19]
+ BBMX[20] BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27]
+ BBMX[28] BBMX[29] BBMX[30] BBMX[31] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4]
+ BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9]
+ LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18]
+ LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27]
+ LDB[28] LDB[29] LDB[30] LDB[31] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5]
+ LDT[6] LDT[7] LDT[8] LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15]
+ LDT[16] LDT[17] LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24]
+ LDT[25] LDT[26] LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] VSS VDDA PWR VSSX
+ BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9]
+ BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBR[16] BBR[17] BBR[18]
+ BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27]
+ BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33] BBR[34] BBR[35] BBR[36]
+ BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44] BBR[45]
+ BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52] BBR[53] BBR[54]
+ BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61] BBR[62] BBR[63]
+ BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71] BBR[72]
+ BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96] BBR[97] BBR[98] BBR[99]
+ BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107]
+ BBR[108] BBR[109] BBR[110] BBR[111] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4]
+ BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14]
+ BTR[15] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22] BTR[23]
+ BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31] BTR[32]
+ BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41]
+ BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] BTR[48] BTR[49] BTR[50]
+ BTR[51] BTR[52] BTR[53] BTR[54] BTR[55] BTR[56] BTR[57] BTR[58] BTR[59]
+ BTR[60] BTR[61] BTR[62] BTR[63] BTR[64] BTR[65] BTR[66] BTR[67] BTR[68]
+ BTR[69] BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76] BTR[77]
+ BTR[78] BTR[79] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85] BTR[86]
+ BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94] BTR[95]
+ BTR[96] BTR[97] BTR[98] BTR[99] BTR[100] BTR[101] BTR[102] BTR[103]
+ BTR[104] BTR[105] BTR[106] BTR[107] BTR[108] BTR[109] BTR[110] BTR[111]
+ BTR[112] BTR[113] BTR[114] BTR[115] BTR[116] BTR[117] BTR[118] BTR[119]
+ BTR[120] BTR[121] BTR[122] BTR[123] BTR[124] BTR[125] BTR[126] BTR[127]
+ CSC[0] CSC[1] CSC[2] CSC[3] RBSC[0] RBSC[1] RBSC[2] RBSC[3] SBC[1] SBC[2]
+ SBC[3] SBC[4] WBSC[0] WBSC[1] WBSC[2] WBSC[3] WMHC[0] WMHC[1] WMHC[2] SPUC
+ BPUC AGC VNW SAETC BSTBC SAPRC
*.pininfo BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B BBMX[16]:B BBMX[17]:B
*.pininfo BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B
*.pininfo BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B BBMX[28]:B BBMX[29]:B
*.pininfo BBMX[30]:B BBMX[31]:B BTMX[0]:B BTMX[1]:B BTMX[2]:B BTMX[3]:B
*.pininfo BTMX[4]:B BTMX[5]:B BTMX[6]:B BTMX[7]:B BTMX[8]:B BTMX[9]:B
*.pininfo BTMX[10]:B BTMX[11]:B BTMX[12]:B BTMX[13]:B BTMX[14]:B BTMX[15]:B
*.pininfo BTMX[16]:B BTMX[17]:B BTMX[18]:B BTMX[19]:B BTMX[20]:B BTMX[21]:B
*.pininfo BTMX[22]:B BTMX[23]:B BTMX[24]:B BTMX[25]:B BTMX[26]:B BTMX[27]:B
*.pininfo BTMX[28]:B BTMX[29]:B BTMX[30]:B BTMX[31]:B GBW[0]:B GBW[1]:B
*.pininfo GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B
*.pininfo GD[1]:B GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B
*.pininfo GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B
*.pininfo GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B
*.pininfo GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B
*.pininfo GRD0[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B
*.pininfo GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B
*.pininfo GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B
*.pininfo GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B
*.pininfo GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B
*.pininfo GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B
*.pininfo GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B
*.pininfo GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B
*.pininfo GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B
*.pininfo GRD3[31]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDB[4]:B LDB[5]:B
*.pininfo LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B LDB[12]:B
*.pininfo LDB[13]:B LDB[14]:B LDB[15]:B LDB[16]:B LDB[17]:B LDB[18]:B
*.pininfo LDB[19]:B LDB[20]:B LDB[21]:B LDB[22]:B LDB[23]:B LDB[24]:B
*.pininfo LDB[25]:B LDB[26]:B LDB[27]:B LDB[28]:B LDB[29]:B LDB[30]:B
*.pininfo LDB[31]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B LDT[4]:B LDT[5]:B
*.pininfo LDT[6]:B LDT[7]:B LDT[8]:B LDT[9]:B LDT[10]:B LDT[11]:B LDT[12]:B
*.pininfo LDT[13]:B LDT[14]:B LDT[15]:B LDT[16]:B LDT[17]:B LDT[18]:B
*.pininfo LDT[19]:B LDT[20]:B LDT[21]:B LDT[22]:B LDT[23]:B LDT[24]:B
*.pininfo LDT[25]:B LDT[26]:B LDT[27]:B LDT[28]:B LDT[29]:B LDT[30]:B
*.pininfo LDT[31]:B VSS:B VDDA:B PWR:B VSSX:B BBR[0]:B BBR[1]:B BBR[2]:B
*.pininfo BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B BBR[8]:B BBR[9]:B
*.pininfo BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B BBR[15]:B
*.pininfo BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B BBR[21]:B
*.pininfo BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B BBR[27]:B
*.pininfo BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B BBR[32]:B BBR[33]:B
*.pininfo BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B BBR[39]:B
*.pininfo BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B BBR[45]:B
*.pininfo BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B BBR[50]:B BBR[51]:B
*.pininfo BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B BBR[57]:B
*.pininfo BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B BBR[63]:B
*.pininfo BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B BBR[68]:B BBR[69]:B
*.pininfo BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B BBR[74]:B BBR[75]:B
*.pininfo BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B BBR[80]:B BBR[81]:B
*.pininfo BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B BBR[87]:B
*.pininfo BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B BBR[93]:B
*.pininfo BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B BBR[98]:B BBR[99]:B
*.pininfo BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B BBR[105]:B
*.pininfo BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B BBR[111]:B
*.pininfo BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B BBR[116]:B BBR[117]:B
*.pininfo BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B BBR[122]:B BBR[123]:B
*.pininfo BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B BTR[0]:B BTR[1]:B
*.pininfo BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B BTR[7]:B BTR[8]:B
*.pininfo BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B BTR[14]:B
*.pininfo BTR[15]:B BTR[16]:B BTR[17]:B BTR[18]:B BTR[19]:B BTR[20]:B
*.pininfo BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B BTR[25]:B BTR[26]:B
*.pininfo BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B BTR[31]:B BTR[32]:B
*.pininfo BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B BTR[37]:B BTR[38]:B
*.pininfo BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B BTR[43]:B BTR[44]:B
*.pininfo BTR[45]:B BTR[46]:B BTR[47]:B BTR[48]:B BTR[49]:B BTR[50]:B
*.pininfo BTR[51]:B BTR[52]:B BTR[53]:B BTR[54]:B BTR[55]:B BTR[56]:B
*.pininfo BTR[57]:B BTR[58]:B BTR[59]:B BTR[60]:B BTR[61]:B BTR[62]:B
*.pininfo BTR[63]:B BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B BTR[68]:B
*.pininfo BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B BTR[74]:B
*.pininfo BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B BTR[80]:B
*.pininfo BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B BTR[85]:B BTR[86]:B
*.pininfo BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B BTR[91]:B BTR[92]:B
*.pininfo BTR[93]:B BTR[94]:B BTR[95]:B BTR[96]:B BTR[97]:B BTR[98]:B
*.pininfo BTR[99]:B BTR[100]:B BTR[101]:B BTR[102]:B BTR[103]:B BTR[104]:B
*.pininfo BTR[105]:B BTR[106]:B BTR[107]:B BTR[108]:B BTR[109]:B BTR[110]:B
*.pininfo BTR[111]:B BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B BTR[116]:B
*.pininfo BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B BTR[122]:B
*.pininfo BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B CSC[0]:B
*.pininfo CSC[1]:B CSC[2]:B CSC[3]:B RBSC[0]:B RBSC[1]:B RBSC[2]:B RBSC[3]:B
*.pininfo SBC[1]:B SBC[2]:B SBC[3]:B SBC[4]:B WBSC[0]:B WBSC[1]:B WBSC[2]:B
*.pininfo WBSC[3]:B WMHC[0]:B WMHC[1]:B WMHC[2]:B SPUC:B BPUC:B AGC:B VNW:B
*.pininfo SAETC:B BSTBC:B SAPRC:B
XXLIO_LOCIO_R VSS VDDA PWR CSC[0] CSC[1] CSC[2] CSC[3] RBSC[0] RBSC[1]
+ RBSC[2] RBSC[3] SBC[1] SBC[2] SBC[3] SBC[4] WBSC[0] WBSC[1] WBSC[2] WBSC[3]
+ WMHC[0] WMHC[1] WMHC[2] SPUC BPUC AGC VNW SAETC BSTBC SAPRC BBMX[0] BBMX[1]
+ BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10]
+ BBMX[11] BBMX[12] BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18]
+ BBMX[19] BBMX[20] BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26]
+ BBMX[27] BBMX[28] BBMX[29] BBMX[30] BBMX[31] BTMX[0] BTMX[1] BTMX[2]
+ BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11]
+ BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19]
+ BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27]
+ BTMX[28] BTMX[29] BTMX[30] BTMX[31] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4]
+ GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16]
+ GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9]
+ GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17]
+ GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25]
+ GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1]
+ GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10]
+ GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11]
+ GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27]
+ GRD3[28] GRD3[29] GRD3[30] GRD3[31] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4]
+ LDB[5] LDB[6] LDB[7] LDB[8] LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14]
+ LDB[15] LDB[16] LDB[17] LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23]
+ LDB[24] LDB[25] LDB[26] LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDT[0]
+ LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9] LDT[10]
+ LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18] LDT[19]
+ LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27] LDT[28]
+ LDT[29] LDT[30] LDT[31] VSSX BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5]
+ BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24]
+ BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33]
+ BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42]
+ BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69]
+ BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78]
+ BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87]
+ BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96]
+ BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104]
+ BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112]
+ BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120]
+ BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BTR[0]
+ BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10]
+ BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19]
+ BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28]
+ BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37]
+ BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46]
+ BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55]
+ BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82]
+ BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91]
+ BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127] spram_4096x16m16b1pm2re1PM2M16B1ARR m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_R

.subckt spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCCEN XB[0] XB[1] XB[2] XB[3]
+ XC[0] XC[1] XC[2] XC[3] CSH_LD XA[0] XA[1] XA[2] XA[3] GRST WMO[0] WMO[1]
+ WMO[2] CSH_RR ag_ctrl PWR BPUI ZRR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+ QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] YSEL[0] YSEL[1] YSEL[2] YSEL[3]
+ LRST VSB[1] VSB[2] VSB[3] VSB[4] WLRST XWB[0] XWB[1] XWB[2] XWB[3] RMO[0]
+ RMO[1] RMO[2] VNW SPUI RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] EN
+ CSH_ENB T1EN ENB VDDA BPUC SPUC VSS AGC SBC[1] SBC[2] SBC[3] SBC[4] BKSEL
+ CSC[0] CSC[1] CSC[2] CSC[3] BSTBC SAETC SAPRC WMHC[0] WMHC[1] WMHC[2]
+ XZB[0] XARMSBB_R[0] XARMSBB_R[1] XARMSBB_R[2] XARMSBB_R[3] XARLSBA_R[0]
+ XARLSBA_R[1] XARLSBA_R[2] XARLSBA_R[3] LCLKB LXWB_R[0] LXWB_R[1] LXWB_R[2]
+ LXWB_R[3] XARMSBA_R[0] XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] DBL1 WBSC[0]
+ WBSC[1] WBSC[2] WBSC[3] RBSC[0] RBSC[1] RBSC[2] RBSC[3]
*.pininfo XB[0]:B XB[1]:B XB[2]:B XB[3]:B XC[0]:B XC[1]:B XC[2]:B XC[3]:B
*.pininfo CSH_LD:B XA[0]:B XA[1]:B XA[2]:B XA[3]:B GRST:B WMO[0]:B WMO[1]:B
*.pininfo WMO[2]:B CSH_RR:B ag_ctrl:B PWR:B BPUI:B ZRR:B QT[2]:B QT[3]:B
*.pininfo QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B
*.pininfo QT[12]:B QT[13]:B YSEL[0]:B YSEL[1]:B YSEL[2]:B YSEL[3]:B LRST:B
*.pininfo VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B WLRST:B XWB[0]:B XWB[1]:B
*.pininfo XWB[2]:B XWB[3]:B RMO[0]:B RMO[1]:B RMO[2]:B VNW:B SPUI:B RWOUT:B
*.pininfo CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B EN:B CSH_ENB:B
*.pininfo T1EN:B ENB:B VDDA:B BPUC:B SPUC:B VSS:B AGC:B SBC[1]:B SBC[2]:B
*.pininfo SBC[3]:B SBC[4]:B BKSEL:O CSC[0]:O CSC[1]:O CSC[2]:O CSC[3]:O
*.pininfo BSTBC:O SAETC:O SAPRC:O WMHC[0]:O WMHC[1]:O WMHC[2]:O XZB[0]:B
*.pininfo XARMSBB_R[0]:O XARMSBB_R[1]:O XARMSBB_R[2]:O XARMSBB_R[3]:O
*.pininfo XARLSBA_R[0]:O XARLSBA_R[1]:O XARLSBA_R[2]:O XARLSBA_R[3]:O LCLKB:B
*.pininfo LXWB_R[0]:O LXWB_R[1]:O LXWB_R[2]:O LXWB_R[3]:O XARMSBA_R[0]:O
*.pininfo XARMSBA_R[1]:O XARMSBA_R[2]:O XARMSBA_R[3]:O DBL1:B WBSC[0]:O
*.pininfo WBSC[1]:O WBSC[2]:O WBSC[3]:O RBSC[0]:O RBSC[1]:O RBSC[2]:O
*.pininfo RBSC[3]:O
XXc0r0 BPUC BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] EN ENB GRST LRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+ QT[9] QT[10] QT[11] QT[12] QT[13] RMO[0] RMO[1] RMO[2] RWOUT SPUC SPUI T1EN
+ VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLRST WMO[0] WMO[1] WMO[2] XA[0]
+ XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3] XWB[0]
+ XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] ZB2 ZRR ag_ctrl
+ sactl_pg m=1
XXc1r0 AGC BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ EN ENB GRST LRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+ QT[11] QT[12] QT[13] RMO[0] RMO[1] RMO[2] RWOUT SBC[1] SBC[2] SBC[3] SBC[4]
+ SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLRST WMO[0] WMO[1]
+ WMO[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2]
+ XC[3] XWB[0] XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] ZB2 ZRR
+ ag_ctrl sactl_sb m=1
XXc2r0 QT[12] QT[13] PWR BKSEL BPUI BSTBC QT[11] CSC[0] CSC[1] CSC[2] CSC[3]
+ CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBL1 EN ENB
+ GRST LCLKB LRST PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+ QT[11] QT[12] QT[13] RMO[0] RMO[1] RMO[2] RWOUT SAETC SAPRC SPUI T1EN VDDA
+ VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLRST WMO[0] WMO[1] WMO[2] WMHC[0]
+ WMHC[1] WMHC[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1]
+ XC[2] XC[3] XWB[0] XWB[1] XWB[2] XWB[3] XZB[0] XZB[1] XZB[2] XZB[3] YSEL[0]
+ YSEL[1] YSEL[2] YSEL[3] XZB[0] XZB[0] ZB2 ZB2 ZRR ag_ctrl sactl m=1
XXc3r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB LRST XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2]
+ XARLSBA_R[3] XARMSBA_R[0] XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3]
+ XARMSBB_R[0] XARMSBB_R[1] XARMSBB_R[2] XARMSBB_R[3] LXWB_R[0] LXWB_R[1]
+ LXWB_R[2] LXWB_R[3] PWR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+ QT[10] QT[11] QT[12] QT[13] RBSC[0] RBSC[1] RBSC[2] RBSC[3] RMO[0] RMO[1]
+ RMO[2] RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WBSC[0]
+ WBSC[1] WBSC[2] WBSC[3] WLRST WMO[0] WMO[1] WMO[2] XA[0] XA[1] XA[2] XA[3]
+ XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3] XWB[0] XWB[1] XWB[2] XWB[3]
+ YSEL[0] YSEL[1] YSEL[2] YSEL[3] XZB[0] ZB2 ZRR ag_ctrl zctl m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCCEN

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE VSSX PWR
+ LDB[0] LDB[1] LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] BBMX[0] BBMX[1]
+ BBMX[2] BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0] LDT[1] LDT[2] LDT[3]
+ GD[0] GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] SPU BPU VNW VDDA VSS AG SB[1] SB[2]
+ SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1[0]
+ Z1[1] Z1[2] Z1[3] Z2[0] Z2[1] Z2[2] Z2[3] BBR[0] BBR[1] BBR[2] BBR[3]
+ BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13]
+ BBR[14] BBR[15] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7]
+ BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] RBS[0] RBS[1]
+ RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
*.pininfo VSSX:B PWR:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B BBMX[0]:B BBMX[1]:B BBMX[2]:B
*.pininfo BBMX[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LDT[0]:B LDT[1]:B
*.pininfo LDT[2]:B LDT[3]:B GD[0]:B GBW[0]:B BTMX[0]:B BTMX[1]:B BTMX[2]:B
*.pininfo BTMX[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B SPU:B BPU:B VNW:B VDDA:B VSS:B AG:B
*.pininfo SB[1]:B SB[2]:B SB[3]:B SB[4]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B
*.pininfo SAET:B WM[0]:B WM[1]:B WM[2]:B BSTB:B SAPR:B Z1[0]:B Z1[1]:B
*.pininfo Z1[2]:B Z1[3]:B Z2[0]:B Z2[1]:B Z2[2]:B Z2[3]:B BBR[0]:B BBR[1]:B
*.pininfo BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B BBR[8]:B
*.pininfo BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B
*.pininfo BBR[15]:B BTR[0]:B BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B
*.pininfo BTR[6]:B BTR[7]:B BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B
*.pininfo BTR[13]:B BTR[14]:B BTR[15]:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B
*.pininfo WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B
XXc0r0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BPU BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SPU VDDA VNW
+ VSS VSSX lio_pg16 m=1
XXc1r0 AG BBMX[0] BBMX[1] BBMX[2] BBMX[3] BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SB[1] SB[2]
+ SB[3] SB[4] VDDA VNW VSS VSSX lio_sb16_64 m=1
XXc2r0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BSTB BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ CS[0] CS[1] CS[2] CS[3] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2]
+ LDT[3] GRD0[0] GRD1[0] GRD2[0] GRD3[0] PWR SAET SAPR VDDA VNW VSS VSSX
+ WM[0] WM[1] WM[2] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1] Z2[2] Z2[3] Z2[0]
+ Z2[1] Z2[2] Z2[3] cache4_lio_64 m=1
XXc3r0 BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9]
+ BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBMX[0] BBMX[1] BBMX[2]
+ BBMX[3] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8]
+ BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTMX[0] BTMX[1]
+ BTMX[2] BTMX[3] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR
+ RBS[0] RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1] WBS[2] WBS[3]
+ lmx_cm4x4 m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY VSSX PWR LDB[0]
+ LDB[1] LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] BBMX[0] BBMX[1]
+ BBMX[2] BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0] LDT[1] LDT[2] LDT[3]
+ GD[0] GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4]
+ BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14]
+ BBR[15] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8]
+ BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] SPU BPU AG SB[1]
+ SB[2] SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] VDDA VSS WBS[0] WBS[1]
+ WBS[2] WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR
+ LDB[4] LDB[5] LDB[6] LDB[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] BBMX[4] BBMX[5]
+ BBMX[6] BBMX[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7] LDT[4] LDT[5] LDT[6] LDT[7]
+ GD[1] GBW[1] BTMX[4] BTMX[5] BTMX[6] BTMX[7] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD0[4] GRD0[5] GRD0[6] GRD0[7] BBR[16] BBR[17] BBR[18] BBR[19]
+ BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27] BBR[28]
+ BBR[29] BBR[30] BBR[31] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21]
+ BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30]
+ BTR[31] LDB[8] LDB[9] LDB[10] LDB[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ BBMX[8] BBMX[9] BBMX[10] BBMX[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] LDT[8]
+ LDT[9] LDT[10] LDT[11] GD[2] GBW[2] BTMX[8] BTMX[9] BTMX[10] BTMX[11]
+ GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD0[8] GRD0[9] GRD0[10] GRD0[11] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BTR[32] BTR[33] BTR[34]
+ BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43]
+ BTR[44] BTR[45] BTR[46] BTR[47] LDB[12] LDB[13] LDB[14] LDB[15] GRD2[12]
+ GRD2[13] GRD2[14] GRD2[15] BBMX[12] BBMX[13] BBMX[14] BBMX[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] LDT[12] LDT[13] LDT[14] LDT[15] GD[3] GBW[3]
+ BTMX[12] BTMX[13] BTMX[14] BTMX[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52]
+ BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61]
+ BBR[62] BBR[63] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ LDB[16] LDB[17] LDB[18] LDB[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19]
+ BBMX[16] BBMX[17] BBMX[18] BBMX[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ LDT[16] LDT[17] LDT[18] LDT[19] GD[4] GBW[4] BTMX[16] BTMX[17] BTMX[18]
+ BTMX[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71]
+ BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] LDB[20] LDB[21] LDB[22]
+ LDB[23] GRD2[20] GRD2[21] GRD2[22] GRD2[23] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] LDT[20] LDT[21] LDT[22]
+ LDT[23] GD[5] GBW[5] BTMX[20] BTMX[21] BTMX[22] BTMX[23] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD0[20] GRD0[21] GRD0[22] GRD0[23] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BTR[80] BTR[81] BTR[82] BTR[83]
+ BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92]
+ BTR[93] BTR[94] BTR[95] LDB[24] LDB[25] LDB[26] LDB[27] GRD2[24] GRD2[25]
+ GRD2[26] GRD2[27] BBMX[24] BBMX[25] BBMX[26] BBMX[27] GRD3[24] GRD3[25]
+ GRD3[26] GRD3[27] LDT[24] LDT[25] LDT[26] LDT[27] GD[6] GBW[6] BTMX[24]
+ BTMX[25] BTMX[26] BTMX[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] BBR[96] BBR[97] BBR[98] BBR[99] BBR[100]
+ BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107] BBR[108]
+ BBR[109] BBR[110] BBR[111] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] LDB[28] LDB[29] LDB[30] LDB[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] BBMX[28] BBMX[29] BBMX[30] BBMX[31] GRD3[28]
+ GRD3[29] GRD3[30] GRD3[31] LDT[28] LDT[29] LDT[30] LDT[31] GD[7] GBW[7]
+ BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1]
+ Z2[2] Z2[3]
*.pininfo VSSX:B PWR:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B BBMX[0]:B BBMX[1]:B BBMX[2]:B
*.pininfo BBMX[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LDT[0]:B LDT[1]:B
*.pininfo LDT[2]:B LDT[3]:B GD[0]:B GBW[0]:B BTMX[0]:B BTMX[1]:B BTMX[2]:B
*.pininfo BTMX[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B BBR[0]:B BBR[1]:B BBR[2]:B BBR[3]:B
*.pininfo BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B BBR[8]:B BBR[9]:B BBR[10]:B
*.pininfo BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B BBR[15]:B BTR[0]:B BTR[1]:B
*.pininfo BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B BTR[7]:B BTR[8]:B
*.pininfo BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B BTR[14]:B
*.pininfo BTR[15]:B SPU:B BPU:B AG:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B VNW:B
*.pininfo RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B VDDA:B VSS:B WBS[0]:B WBS[1]:B
*.pininfo WBS[2]:B WBS[3]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B WM[0]:B WM[1]:B
*.pininfo WM[2]:B SAET:B BSTB:B SAPR:B LDB[4]:B LDB[5]:B LDB[6]:B LDB[7]:B
*.pininfo GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B
*.pininfo LDT[4]:B LDT[5]:B LDT[6]:B LDT[7]:B GD[1]:B GBW[1]:B BTMX[4]:B
*.pininfo BTMX[5]:B BTMX[6]:B BTMX[7]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B BBR[16]:B
*.pininfo BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B BBR[21]:B BBR[22]:B
*.pininfo BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B BBR[27]:B BBR[28]:B
*.pininfo BBR[29]:B BBR[30]:B BBR[31]:B BTR[16]:B BTR[17]:B BTR[18]:B
*.pininfo BTR[19]:B BTR[20]:B BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B
*.pininfo BTR[25]:B BTR[26]:B BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B
*.pininfo BTR[31]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B GRD2[8]:B GRD2[9]:B
*.pininfo GRD2[10]:B GRD2[11]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B LDT[8]:B LDT[9]:B
*.pininfo LDT[10]:B LDT[11]:B GD[2]:B GBW[2]:B BTMX[8]:B BTMX[9]:B BTMX[10]:B
*.pininfo BTMX[11]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B BBR[32]:B BBR[33]:B BBR[34]:B
*.pininfo BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B BBR[39]:B BBR[40]:B
*.pininfo BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B BBR[45]:B BBR[46]:B
*.pininfo BBR[47]:B BTR[32]:B BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B
*.pininfo BTR[37]:B BTR[38]:B BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B
*.pininfo BTR[43]:B BTR[44]:B BTR[45]:B BTR[46]:B BTR[47]:B LDB[12]:B
*.pininfo LDB[13]:B LDB[14]:B LDB[15]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B
*.pininfo GRD2[15]:B BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B GRD3[12]:B
*.pininfo GRD3[13]:B GRD3[14]:B GRD3[15]:B LDT[12]:B LDT[13]:B LDT[14]:B
*.pininfo LDT[15]:B GD[3]:B GBW[3]:B BTMX[12]:B BTMX[13]:B BTMX[14]:B
*.pininfo BTMX[15]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD0[12]:B
*.pininfo GRD0[13]:B GRD0[14]:B GRD0[15]:B BBR[48]:B BBR[49]:B BBR[50]:B
*.pininfo BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B
*.pininfo BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B
*.pininfo BBR[63]:B BTR[48]:B BTR[49]:B BTR[50]:B BTR[51]:B BTR[52]:B
*.pininfo BTR[53]:B BTR[54]:B BTR[55]:B BTR[56]:B BTR[57]:B BTR[58]:B
*.pininfo BTR[59]:B BTR[60]:B BTR[61]:B BTR[62]:B BTR[63]:B LDB[16]:B
*.pininfo LDB[17]:B LDB[18]:B LDB[19]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B BBMX[16]:B BBMX[17]:B BBMX[18]:B BBMX[19]:B GRD3[16]:B
*.pininfo GRD3[17]:B GRD3[18]:B GRD3[19]:B LDT[16]:B LDT[17]:B LDT[18]:B
*.pininfo LDT[19]:B GD[4]:B GBW[4]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B
*.pininfo BTMX[19]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD0[16]:B
*.pininfo GRD0[17]:B GRD0[18]:B GRD0[19]:B BBR[64]:B BBR[65]:B BBR[66]:B
*.pininfo BBR[67]:B BBR[68]:B BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B
*.pininfo BBR[73]:B BBR[74]:B BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B
*.pininfo BBR[79]:B BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B BTR[68]:B
*.pininfo BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B BTR[74]:B
*.pininfo BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B LDB[20]:B
*.pininfo LDB[21]:B LDB[22]:B LDB[23]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B LDT[20]:B LDT[21]:B LDT[22]:B
*.pininfo LDT[23]:B GD[5]:B GBW[5]:B BTMX[20]:B BTMX[21]:B BTMX[22]:B
*.pininfo BTMX[23]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B BBR[80]:B BBR[81]:B BBR[82]:B
*.pininfo BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B BBR[87]:B BBR[88]:B
*.pininfo BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B BBR[93]:B BBR[94]:B
*.pininfo BBR[95]:B BTR[80]:B BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B
*.pininfo BTR[85]:B BTR[86]:B BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B
*.pininfo BTR[91]:B BTR[92]:B BTR[93]:B BTR[94]:B BTR[95]:B LDB[24]:B
*.pininfo LDB[25]:B LDB[26]:B LDB[27]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B
*.pininfo GRD2[27]:B BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B LDT[24]:B LDT[25]:B LDT[26]:B
*.pininfo LDT[27]:B GD[6]:B GBW[6]:B BTMX[24]:B BTMX[25]:B BTMX[26]:B
*.pininfo BTMX[27]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B BBR[96]:B BBR[97]:B BBR[98]:B
*.pininfo BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B
*.pininfo BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B
*.pininfo BBR[111]:B BTR[96]:B BTR[97]:B BTR[98]:B BTR[99]:B BTR[100]:B
*.pininfo BTR[101]:B BTR[102]:B BTR[103]:B BTR[104]:B BTR[105]:B BTR[106]:B
*.pininfo BTR[107]:B BTR[108]:B BTR[109]:B BTR[110]:B BTR[111]:B LDB[28]:B
*.pininfo LDB[29]:B LDB[30]:B LDB[31]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B
*.pininfo GRD2[31]:B BBMX[28]:B BBMX[29]:B BBMX[30]:B BBMX[31]:B GRD3[28]:B
*.pininfo GRD3[29]:B GRD3[30]:B GRD3[31]:B LDT[28]:B LDT[29]:B LDT[30]:B
*.pininfo LDT[31]:B GD[7]:B GBW[7]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B
*.pininfo BTMX[31]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD0[28]:B
*.pininfo GRD0[29]:B GRD0[30]:B GRD0[31]:B BBR[112]:B BBR[113]:B BBR[114]:B
*.pininfo BBR[115]:B BBR[116]:B BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B
*.pininfo BBR[121]:B BBR[122]:B BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B
*.pininfo BBR[127]:B BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B BTR[116]:B
*.pininfo BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B BTR[122]:B
*.pininfo BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B Z1[0]:B
*.pininfo Z1[1]:B Z1[2]:B Z1[3]:B Z2[0]:B Z2[1]:B Z2[2]:B Z2[3]:B
XX00 VSSX PWR LDB[0] LDB[1] LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3]
+ BBMX[0] BBMX[1] BBMX[2] BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0]
+ LDT[1] LDT[2] LDT[3] GD[0] GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD0[0] GRD0[1] GRD0[2] GRD0[3] SPU BPU VNW VDDA
+ VSS AG SB[1] SB[2] SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0] WM[1]
+ WM[2] BSTB SAPR Z1_0[0] Z1_0[1] Z1_0[2] Z1_0[3] Z2_0[0] Z2_0[1] Z2_0[2]
+ Z2_0[3] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8]
+ BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BTR[0] BTR[1] BTR[2]
+ BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12]
+ BTR[13] BTR[14] BTR[15] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2]
+ WBS[3] spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
XX01 VSSX PWR LDB[4] LDB[5] LDB[6] LDB[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ BBMX[4] BBMX[5] BBMX[6] BBMX[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7] LDT[4]
+ LDT[5] LDT[6] LDT[7] GD[1] GBW[1] BTMX[4] BTMX[5] BTMX[6] BTMX[7] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD0[4] GRD0[5] GRD0[6] GRD0[7] SPU BPU VNW VDDA
+ VSS AG SB[1] SB[2] SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0] WM[1]
+ WM[2] BSTB SAPR Z1_1[0] Z1_1[1] Z1_1[2] Z1_1[3] Z2_1[0] Z2_1[1] Z2_1[2]
+ Z2_1[3] BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23]
+ BBR[24] BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BTR[16]
+ BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25]
+ BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31] RBS[0] RBS[1] RBS[2] RBS[3]
+ WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
XX02 VSSX PWR LDB[8] LDB[9] LDB[10] LDB[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ BBMX[8] BBMX[9] BBMX[10] BBMX[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] LDT[8]
+ LDT[9] LDT[10] LDT[11] GD[2] GBW[2] BTMX[8] BTMX[9] BTMX[10] BTMX[11]
+ GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD0[8] GRD0[9] GRD0[10] GRD0[11] SPU BPU
+ VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0]
+ WM[1] WM[2] BSTB SAPR Z1_2[0] Z1_2[1] Z1_2[2] Z1_2[3] Z2_2[0] Z2_2[1]
+ Z2_2[2] Z2_2[3] BBR[32] BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38]
+ BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47]
+ BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40]
+ BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] RBS[0] RBS[1]
+ RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
XX03 VSSX PWR LDB[12] LDB[13] LDB[14] LDB[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] BBMX[12] BBMX[13] BBMX[14] BBMX[15] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] LDT[12] LDT[13] LDT[14] LDT[15] GD[3] GBW[3] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_3[0] Z1_3[1] Z1_3[2]
+ Z1_3[3] Z2_3[0] Z2_3[1] Z2_3[2] Z2_3[3] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53]
+ BTR[54] BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62]
+ BTR[63] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
XX04 VSSX PWR LDB[16] LDB[17] LDB[18] LDB[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] BBMX[16] BBMX[17] BBMX[18] BBMX[19] GRD3[16] GRD3[17] GRD3[18]
+ GRD3[19] LDT[16] LDT[17] LDT[18] LDT[19] GD[4] GBW[4] BTMX[16] BTMX[17]
+ BTMX[18] BTMX[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD0[16] GRD0[17]
+ GRD0[18] GRD0[19] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_4[0] Z1_4[1] Z1_4[2]
+ Z1_4[3] Z2_4[0] Z2_4[1] Z2_4[2] Z2_4[3] BBR[64] BBR[65] BBR[66] BBR[67]
+ BBR[68] BBR[69] BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76]
+ BBR[77] BBR[78] BBR[79] BTR[64] BTR[65] BTR[66] BTR[67] BTR[68] BTR[69]
+ BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76] BTR[77] BTR[78]
+ BTR[79] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
XX05 VSSX PWR LDB[20] LDB[21] LDB[22] LDB[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] BBMX[20] BBMX[21] BBMX[22] BBMX[23] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] LDT[20] LDT[21] LDT[22] LDT[23] GD[5] GBW[5] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_5[0] Z1_5[1] Z1_5[2]
+ Z1_5[3] Z2_5[0] Z2_5[1] Z2_5[2] Z2_5[3] BBR[80] BBR[81] BBR[82] BBR[83]
+ BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90] BBR[91] BBR[92]
+ BBR[93] BBR[94] BBR[95] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85]
+ BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94]
+ BTR[95] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
XX06 VSSX PWR LDB[24] LDB[25] LDB[26] LDB[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] BBMX[24] BBMX[25] BBMX[26] BBMX[27] GRD3[24] GRD3[25] GRD3[26]
+ GRD3[27] LDT[24] LDT[25] LDT[26] LDT[27] GD[6] GBW[6] BTMX[24] BTMX[25]
+ BTMX[26] BTMX[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD0[24] GRD0[25]
+ GRD0[26] GRD0[27] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1_6[0] Z1_6[1] Z1_6[2]
+ Z1_6[3] Z2_6[0] Z2_6[1] Z2_6[2] Z2_6[3] BBR[96] BBR[97] BBR[98] BBR[99]
+ BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107]
+ BBR[108] BBR[109] BBR[110] BBR[111] BTR[96] BTR[97] BTR[98] BTR[99]
+ BTR[100] BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107]
+ BTR[108] BTR[109] BTR[110] BTR[111] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0]
+ WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
XX07 VSSX PWR LDB[28] LDB[29] LDB[30] LDB[31] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] BBMX[28] BBMX[29] BBMX[30] BBMX[31] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] LDT[28] LDT[29] LDT[30] LDT[31] GD[7] GBW[7] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR Z1[0] Z1[1] Z1[2] Z1[3]
+ Z2[0] Z2[1] Z2[2] Z2[3] BBR[112] BBR[113] BBR[114] BBR[115] BBR[116]
+ BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123] BBR[124]
+ BBR[125] BBR[126] BBR[127] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2]
+ WBS[3] spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_SLICE m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIORE VSSX PWR LDB[0]
+ LDB[1] LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] BBMX[0] BBMX[1]
+ BBMX[2] BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0] LDT[1] LDT[2] LDT[3]
+ GD GBW BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3]
+ SB[4] CS[0] CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR RBB_R[0]
+ RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8]
+ RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15]
+ RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7]
+ RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14]
+ RBT_R[15] RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
*.pininfo VSSX:B PWR:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B BBMX[0]:B BBMX[1]:B BBMX[2]:B
*.pininfo BBMX[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B LDT[0]:B LDT[1]:B
*.pininfo LDT[2]:B LDT[3]:B GD:B GBW:B BTMX[0]:B BTMX[1]:B BTMX[2]:B
*.pininfo BTMX[3]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B SPU:B BPU:B VNW:B VDDA:B VSS:B AG:B
*.pininfo SB[1]:B SB[2]:B SB[3]:B SB[4]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B
*.pininfo SAET:B WM[0]:B WM[1]:B WM[2]:B BSTB:B SAPR:B RBB_R[0]:B RBB_R[1]:B
*.pininfo RBB_R[2]:B RBB_R[3]:B RBB_R[4]:B RBB_R[5]:B RBB_R[6]:B RBB_R[7]:B
*.pininfo RBB_R[8]:B RBB_R[9]:B RBB_R[10]:B RBB_R[11]:B RBB_R[12]:B
*.pininfo RBB_R[13]:B RBB_R[14]:B RBB_R[15]:B RBT_R[0]:B RBT_R[1]:B
*.pininfo RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B RBT_R[5]:B RBT_R[6]:B RBT_R[7]:B
*.pininfo RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B RBT_R[11]:B RBT_R[12]:B
*.pininfo RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B RBS[0]:B RBS[1]:B RBS[2]:B
*.pininfo RBS[3]:B WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B
XXc0r0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BPU BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDB[0]
+ LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SPU VDDA VNW VSS VSSX
+ lio_pg16 m=1
XXc1r0 AG BBMX[0] BBMX[1] BBMX[2] BBMX[3] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GBW
+ GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDB[0] LDB[1]
+ LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR SB[1] SB[2] SB[3] SB[4] VDDA
+ VNW VSS VSSX lio_sb16_64 m=1
XXc2r0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BSTB BTMX[0] BTMX[1] BTMX[2] BTMX[3]
+ CS[0] CS[1] CS[2] CS[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3]
+ GRD0[0] GRD1[0] GRD2[0] GRD3[0] PWR SAET SAPR VDDA VNW VSS VSSX WM[0] WM[1]
+ WM[2] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1] Z2[2] Z2[3] Z2[0] Z2[1] Z2[2]
+ Z2[3] cache4_lio_64 m=1
XXc3r0 RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6]
+ RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13]
+ RBB_R[14] RBB_R[15] BBMX[0] BBMX[1] BBMX[2] BBMX[3] RBT_R[0] RBT_R[1]
+ RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9]
+ RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15] BTMX[0] BTMX[1]
+ BTMX[2] BTMX[3] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] LDB[0] LDB[1] LDB[2] LDB[3] LDT[0] LDT[1] LDT[2] LDT[3] PWR RBS[0]
+ RBS[1] RBS[2] RBS[3] VDDA VNW VSS VSSX WBS[0] WBS[1] WBS[2] WBS[3]
+ lmx_cm4x4 m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIORE

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIO_RED VSSX PWR RLDB[0]
+ RLDB[1] RLDB[2] RLDB[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RBBMX[0]
+ RBBMX[1] RBBMX[2] RBBMX[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RLDT[0]
+ RLDT[1] RLDT[2] RLDT[3] RGD RGBW RBTMX[0] RBTMX[1] RBTMX[2] RBTMX[3]
+ RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3]
+ RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7]
+ RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14]
+ RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6]
+ RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13]
+ RBT_R[14] RBT_R[15] SPU BPU AG SB[1] SB[2] SB[3] SB[4] VNW RBS[0] RBS[1]
+ RBS[2] RBS[3] VDDA VSS WBS[0] WBS[1] WBS[2] WBS[3] CS[0] CS[1] CS[2] CS[3]
+ SAET WM[0] WM[1] WM[2] BSTB SAPR
*.pininfo VSSX:B PWR:B RLDB[0]:B RLDB[1]:B RLDB[2]:B RLDB[3]:B RGRD2[0]:B
*.pininfo RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B
*.pininfo RBBMX[3]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B RLDT[0]:B
*.pininfo RLDT[1]:B RLDT[2]:B RLDT[3]:B RGD:B RGBW:B RBTMX[0]:B RBTMX[1]:B
*.pininfo RBTMX[2]:B RBTMX[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B RBB_R[0]:B RBB_R[1]:B
*.pininfo RBB_R[2]:B RBB_R[3]:B RBB_R[4]:B RBB_R[5]:B RBB_R[6]:B RBB_R[7]:B
*.pininfo RBB_R[8]:B RBB_R[9]:B RBB_R[10]:B RBB_R[11]:B RBB_R[12]:B
*.pininfo RBB_R[13]:B RBB_R[14]:B RBB_R[15]:B RBT_R[0]:B RBT_R[1]:B
*.pininfo RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B RBT_R[5]:B RBT_R[6]:B RBT_R[7]:B
*.pininfo RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B RBT_R[11]:B RBT_R[12]:B
*.pininfo RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B SPU:B BPU:B AG:B SB[1]:B
*.pininfo SB[2]:B SB[3]:B SB[4]:B VNW:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B
*.pininfo VDDA:B VSS:B WBS[0]:B WBS[1]:B WBS[2]:B WBS[3]:B CS[0]:B CS[1]:B
*.pininfo CS[2]:B CS[3]:B SAET:B WM[0]:B WM[1]:B WM[2]:B BSTB:B SAPR:B
XX00 VSSX PWR RLDB[0] RLDB[1] RLDB[2] RLDB[3] RGRD2[0] RGRD2[1] RGRD2[2]
+ RGRD2[3] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RGRD3[0] RGRD3[1] RGRD3[2]
+ RGRD3[3] RLDT[0] RLDT[1] RLDT[2] RLDT[3] RGD RGBW RBTMX[0] RBTMX[1]
+ RBTMX[2] RBTMX[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD0[0] RGRD0[1]
+ RGRD0[2] RGRD0[3] SPU BPU VNW VDDA VSS AG SB[1] SB[2] SB[3] SB[4] CS[0]
+ CS[1] CS[2] CS[3] SAET WM[0] WM[1] WM[2] BSTB SAPR RBB_R[0] RBB_R[1]
+ RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9]
+ RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0]
+ RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8]
+ RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15] RBS[0]
+ RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2] WBS[3]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIORE m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIO_RED

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA PWR VDDA VSS SPU BPU AG
+ SB[1] SB[2] SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1]
+ WBS[2] WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR VSSX
+ LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9]
+ LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18]
+ LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27]
+ LDB[28] LDB[29] LDB[30] LDB[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6]
+ BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13] BBMX[14]
+ BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29] BBMX[30]
+ BBMX[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9]
+ LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18]
+ LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27]
+ LDT[28] LDT[29] LDT[30] LDT[31] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6]
+ GD[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] BTMX[0]
+ BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9]
+ BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16] BTMX[17]
+ BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24] BTMX[25]
+ BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10]
+ GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26]
+ GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4]
+ BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14]
+ BBR[15] BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23]
+ BBR[24] BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50]
+ BBR[51] BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59]
+ BBR[60] BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68]
+ BBR[69] BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77]
+ BBR[78] BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86]
+ BBR[87] BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95]
+ BBR[96] BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103]
+ BBR[104] BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111]
+ BBR[112] BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119]
+ BBR[120] BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127]
+ BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9]
+ BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18]
+ BTR[19] BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27]
+ BTR[28] BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36]
+ BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45]
+ BTR[46] BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ BTR[64] BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72]
+ BTR[73] BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81]
+ BTR[82] BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90]
+ BTR[91] BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99]
+ BTR[100] BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107]
+ BTR[108] BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127] RLDB[0] RLDB[1] RLDB[2] RLDB[3]
+ RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3]
+ RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RLDT[0] RLDT[1] RLDT[2] RLDT[3] RGD
+ RGBW RBTMX[0] RBTMX[1] RBTMX[2] RBTMX[3] RGRD1[0] RGRD1[1] RGRD1[2]
+ RGRD1[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RBB_R[0] RBB_R[1] RBB_R[2]
+ RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10]
+ RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1]
+ RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9]
+ RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15]
*.pininfo PWR:B VDDA:B VSS:B SPU:B BPU:B AG:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B
*.pininfo VNW:B RBS[0]:B RBS[1]:B RBS[2]:B RBS[3]:B WBS[0]:B WBS[1]:B
*.pininfo WBS[2]:B WBS[3]:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B WM[0]:B WM[1]:B
*.pininfo WM[2]:B SAET:B BSTB:B SAPR:B VSSX:B LDB[0]:B LDB[1]:B LDB[2]:B
*.pininfo LDB[3]:B LDB[4]:B LDB[5]:B LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B
*.pininfo LDB[10]:B LDB[11]:B LDB[12]:B LDB[13]:B LDB[14]:B LDB[15]:B
*.pininfo LDB[16]:B LDB[17]:B LDB[18]:B LDB[19]:B LDB[20]:B LDB[21]:B
*.pininfo LDB[22]:B LDB[23]:B LDB[24]:B LDB[25]:B LDB[26]:B LDB[27]:B
*.pininfo LDB[28]:B LDB[29]:B LDB[30]:B LDB[31]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B
*.pininfo GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B
*.pininfo GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B
*.pininfo GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B
*.pininfo BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B BBMX[16]:B BBMX[17]:B
*.pininfo BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B
*.pininfo BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B BBMX[28]:B BBMX[29]:B
*.pininfo BBMX[30]:B BBMX[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B
*.pininfo GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B GRD3[9]:B
*.pininfo GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B
*.pininfo GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B GRD3[21]:B
*.pininfo GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B GRD3[27]:B
*.pininfo GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B LDT[0]:B LDT[1]:B
*.pininfo LDT[2]:B LDT[3]:B LDT[4]:B LDT[5]:B LDT[6]:B LDT[7]:B LDT[8]:B
*.pininfo LDT[9]:B LDT[10]:B LDT[11]:B LDT[12]:B LDT[13]:B LDT[14]:B
*.pininfo LDT[15]:B LDT[16]:B LDT[17]:B LDT[18]:B LDT[19]:B LDT[20]:B
*.pininfo LDT[21]:B LDT[22]:B LDT[23]:B LDT[24]:B LDT[25]:B LDT[26]:B
*.pininfo LDT[27]:B LDT[28]:B LDT[29]:B LDT[30]:B LDT[31]:B GD[0]:B GD[1]:B
*.pininfo GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GBW[0]:B GBW[1]:B
*.pininfo GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B BTMX[0]:B
*.pininfo BTMX[1]:B BTMX[2]:B BTMX[3]:B BTMX[4]:B BTMX[5]:B BTMX[6]:B
*.pininfo BTMX[7]:B BTMX[8]:B BTMX[9]:B BTMX[10]:B BTMX[11]:B BTMX[12]:B
*.pininfo BTMX[13]:B BTMX[14]:B BTMX[15]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B
*.pininfo BTMX[19]:B BTMX[20]:B BTMX[21]:B BTMX[22]:B BTMX[23]:B BTMX[24]:B
*.pininfo BTMX[25]:B BTMX[26]:B BTMX[27]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B
*.pininfo BTMX[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B BBR[0]:B
*.pininfo BBR[1]:B BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B
*.pininfo BBR[8]:B BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B
*.pininfo BBR[15]:B BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B
*.pininfo BBR[21]:B BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B
*.pininfo BBR[27]:B BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B BBR[32]:B
*.pininfo BBR[33]:B BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B
*.pininfo BBR[39]:B BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B
*.pininfo BBR[45]:B BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B BBR[50]:B
*.pininfo BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B
*.pininfo BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B
*.pininfo BBR[63]:B BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B BBR[68]:B
*.pininfo BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B BBR[74]:B
*.pininfo BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B BBR[80]:B
*.pininfo BBR[81]:B BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B
*.pininfo BBR[87]:B BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B
*.pininfo BBR[93]:B BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B BBR[98]:B
*.pininfo BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B
*.pininfo BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B
*.pininfo BBR[111]:B BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B BBR[116]:B
*.pininfo BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B BBR[122]:B
*.pininfo BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B BTR[0]:B
*.pininfo BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B BTR[7]:B
*.pininfo BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B BTR[14]:B
*.pininfo BTR[15]:B BTR[16]:B BTR[17]:B BTR[18]:B BTR[19]:B BTR[20]:B
*.pininfo BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B BTR[25]:B BTR[26]:B
*.pininfo BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B BTR[31]:B BTR[32]:B
*.pininfo BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B BTR[37]:B BTR[38]:B
*.pininfo BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B BTR[43]:B BTR[44]:B
*.pininfo BTR[45]:B BTR[46]:B BTR[47]:B BTR[48]:B BTR[49]:B BTR[50]:B
*.pininfo BTR[51]:B BTR[52]:B BTR[53]:B BTR[54]:B BTR[55]:B BTR[56]:B
*.pininfo BTR[57]:B BTR[58]:B BTR[59]:B BTR[60]:B BTR[61]:B BTR[62]:B
*.pininfo BTR[63]:B BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B BTR[68]:B
*.pininfo BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B BTR[74]:B
*.pininfo BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B BTR[80]:B
*.pininfo BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B BTR[85]:B BTR[86]:B
*.pininfo BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B BTR[91]:B BTR[92]:B
*.pininfo BTR[93]:B BTR[94]:B BTR[95]:B BTR[96]:B BTR[97]:B BTR[98]:B
*.pininfo BTR[99]:B BTR[100]:B BTR[101]:B BTR[102]:B BTR[103]:B BTR[104]:B
*.pininfo BTR[105]:B BTR[106]:B BTR[107]:B BTR[108]:B BTR[109]:B BTR[110]:B
*.pininfo BTR[111]:B BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B BTR[116]:B
*.pininfo BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B BTR[122]:B
*.pininfo BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B RLDB[0]:B
*.pininfo RLDB[1]:B RLDB[2]:B RLDB[3]:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B
*.pininfo RGRD2[3]:B RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B RBBMX[3]:B RGRD3[0]:B
*.pininfo RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B RLDT[0]:B RLDT[1]:B RLDT[2]:B
*.pininfo RLDT[3]:B RGD:B RGBW:B RBTMX[0]:B RBTMX[1]:B RBTMX[2]:B RBTMX[3]:B
*.pininfo RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RBB_R[0]:B RBB_R[1]:B RBB_R[2]:B RBB_R[3]:B
*.pininfo RBB_R[4]:B RBB_R[5]:B RBB_R[6]:B RBB_R[7]:B RBB_R[8]:B RBB_R[9]:B
*.pininfo RBB_R[10]:B RBB_R[11]:B RBB_R[12]:B RBB_R[13]:B RBB_R[14]:B
*.pininfo RBB_R[15]:B RBT_R[0]:B RBT_R[1]:B RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B
*.pininfo RBT_R[5]:B RBT_R[6]:B RBT_R[7]:B RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B
*.pininfo RBT_R[11]:B RBT_R[12]:B RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B
XXspram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY_0_R VSSX PWR LDB[0] LDB[1]
+ LDB[2] LDB[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] BBMX[0] BBMX[1] BBMX[2]
+ BBMX[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] LDT[0] LDT[1] LDT[2] LDT[3] GD[0]
+ GBW[0] BTMX[0] BTMX[1] BTMX[2] BTMX[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5]
+ BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9]
+ BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] SPU BPU AG SB[1] SB[2]
+ SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] VDDA VSS WBS[0] WBS[1] WBS[2]
+ WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR LDB[4]
+ LDB[5] LDB[6] LDB[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] BBMX[4] BBMX[5]
+ BBMX[6] BBMX[7] GRD3[4] GRD3[5] GRD3[6] GRD3[7] LDT[4] LDT[5] LDT[6] LDT[7]
+ GD[1] GBW[1] BTMX[4] BTMX[5] BTMX[6] BTMX[7] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD0[4] GRD0[5] GRD0[6] GRD0[7] BBR[16] BBR[17] BBR[18] BBR[19]
+ BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27] BBR[28]
+ BBR[29] BBR[30] BBR[31] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21]
+ BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30]
+ BTR[31] LDB[8] LDB[9] LDB[10] LDB[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ BBMX[8] BBMX[9] BBMX[10] BBMX[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] LDT[8]
+ LDT[9] LDT[10] LDT[11] GD[2] GBW[2] BTMX[8] BTMX[9] BTMX[10] BTMX[11]
+ GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD0[8] GRD0[9] GRD0[10] GRD0[11] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BTR[32] BTR[33] BTR[34]
+ BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43]
+ BTR[44] BTR[45] BTR[46] BTR[47] LDB[12] LDB[13] LDB[14] LDB[15] GRD2[12]
+ GRD2[13] GRD2[14] GRD2[15] BBMX[12] BBMX[13] BBMX[14] BBMX[15] GRD3[12]
+ GRD3[13] GRD3[14] GRD3[15] LDT[12] LDT[13] LDT[14] LDT[15] GD[3] GBW[3]
+ BTMX[12] BTMX[13] BTMX[14] BTMX[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52]
+ BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61]
+ BBR[62] BBR[63] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ LDB[16] LDB[17] LDB[18] LDB[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19]
+ BBMX[16] BBMX[17] BBMX[18] BBMX[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ LDT[16] LDT[17] LDT[18] LDT[19] GD[4] GBW[4] BTMX[16] BTMX[17] BTMX[18]
+ BTMX[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71]
+ BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] LDB[20] LDB[21] LDB[22]
+ LDB[23] GRD2[20] GRD2[21] GRD2[22] GRD2[23] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] LDT[20] LDT[21] LDT[22]
+ LDT[23] GD[5] GBW[5] BTMX[20] BTMX[21] BTMX[22] BTMX[23] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD0[20] GRD0[21] GRD0[22] GRD0[23] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BTR[80] BTR[81] BTR[82] BTR[83]
+ BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92]
+ BTR[93] BTR[94] BTR[95] LDB[24] LDB[25] LDB[26] LDB[27] GRD2[24] GRD2[25]
+ GRD2[26] GRD2[27] BBMX[24] BBMX[25] BBMX[26] BBMX[27] GRD3[24] GRD3[25]
+ GRD3[26] GRD3[27] LDT[24] LDT[25] LDT[26] LDT[27] GD[6] GBW[6] BTMX[24]
+ BTMX[25] BTMX[26] BTMX[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] BBR[96] BBR[97] BBR[98] BBR[99] BBR[100]
+ BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107] BBR[108]
+ BBR[109] BBR[110] BBR[111] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] LDB[28] LDB[29] LDB[30] LDB[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] BBMX[28] BBMX[29] BBMX[30] BBMX[31] GRD3[28]
+ GRD3[29] GRD3[30] GRD3[31] LDT[28] LDT[29] LDT[30] LDT[31] GD[7] GBW[7]
+ BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127] Z1[0] Z1[1] Z1[2] Z1[3] Z2[0] Z2[1]
+ Z2[2] Z2[3] spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIOARY m=1
XXspram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIO_RED_0 VSSX PWR RLDB[0]
+ RLDB[1] RLDB[2] RLDB[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RBBMX[0]
+ RBBMX[1] RBBMX[2] RBBMX[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RLDT[0]
+ RLDT[1] RLDT[2] RLDT[3] RGD RGBW RBTMX[0] RBTMX[1] RBTMX[2] RBTMX[3]
+ RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3]
+ RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7]
+ RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14]
+ RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6]
+ RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13]
+ RBT_R[14] RBT_R[15] SPU BPU AG SB[1] SB[2] SB[3] SB[4] VNW RBS[0] RBS[1]
+ RBS[2] RBS[3] VDDA VSS WBS[0] WBS[1] WBS[2] WBS[3] CS[0] CS[1] CS[2] CS[3]
+ SAET WM[0] WM[1] WM[2] BSTB SAPR
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_LIO_RED m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA

.subckt spram_4096x16m16b1pm2re1PM2M16B1ARL VSS VDDA PWR CS[0] CS[1] CS[2]
+ CS[3] RBS[0] RBS[1] RBS[2] RBS[3] SB[1] SB[2] SB[3] SB[4] WBS[0] WBS[1]
+ WBS[2] WBS[3] WM[0] WM[1] WM[2] SPU BPU AG VNW SAET BSTB SAPR BBMX[0]
+ BBMX[1] BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9]
+ BBMX[10] BBMX[11] BBMX[12] BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17]
+ BBMX[18] BBMX[19] BBMX[20] BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25]
+ BBMX[26] BBMX[27] BBMX[28] BBMX[29] BBMX[30] BBMX[31] BTMX[0] BTMX[1]
+ BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10]
+ BTMX[11] BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18]
+ BTMX[19] BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26]
+ BTMX[27] BTMX[28] BTMX[29] BTMX[30] BTMX[31] GBW[0] GBW[1] GBW[2] GBW[3]
+ GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16]
+ GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9]
+ GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17]
+ GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25]
+ GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1]
+ GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10]
+ GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11]
+ GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27]
+ GRD3[28] GRD3[29] GRD3[30] GRD3[31] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4]
+ LDB[5] LDB[6] LDB[7] LDB[8] LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14]
+ LDB[15] LDB[16] LDB[17] LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23]
+ LDB[24] LDB[25] LDB[26] LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDT[0]
+ LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9] LDT[10]
+ LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18] LDT[19]
+ LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27] LDT[28]
+ LDT[29] LDT[30] LDT[31] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0]
+ RBTMX[1] RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0]
+ RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0]
+ RGRD3[1] RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1]
+ RLDT[2] RLDT[3] VSSX RGD RGBW BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5]
+ BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24]
+ BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33]
+ BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42]
+ BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69]
+ BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78]
+ BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87]
+ BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96]
+ BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104]
+ BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112]
+ BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120]
+ BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BTR[0]
+ BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10]
+ BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19]
+ BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28]
+ BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37]
+ BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46]
+ BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55]
+ BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82]
+ BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91]
+ BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127] RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4]
+ RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12]
+ RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4]
+ RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12]
+ RBT_R[13] RBT_R[14] RBT_R[15]
*.pininfo VSS:B VDDA:B PWR:B CS[0]:B CS[1]:B CS[2]:B CS[3]:B RBS[0]:B
*.pininfo RBS[1]:B RBS[2]:B RBS[3]:B SB[1]:B SB[2]:B SB[3]:B SB[4]:B WBS[0]:B
*.pininfo WBS[1]:B WBS[2]:B WBS[3]:B WM[0]:B WM[1]:B WM[2]:B SPU:B BPU:B AG:B
*.pininfo VNW:B SAET:B BSTB:B SAPR:B BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B
*.pininfo BBMX[4]:B BBMX[5]:B BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B
*.pininfo BBMX[10]:B BBMX[11]:B BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B
*.pininfo BBMX[16]:B BBMX[17]:B BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B
*.pininfo BBMX[22]:B BBMX[23]:B BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B
*.pininfo BBMX[28]:B BBMX[29]:B BBMX[30]:B BBMX[31]:B BTMX[0]:B BTMX[1]:B
*.pininfo BTMX[2]:B BTMX[3]:B BTMX[4]:B BTMX[5]:B BTMX[6]:B BTMX[7]:B
*.pininfo BTMX[8]:B BTMX[9]:B BTMX[10]:B BTMX[11]:B BTMX[12]:B BTMX[13]:B
*.pininfo BTMX[14]:B BTMX[15]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B BTMX[19]:B
*.pininfo BTMX[20]:B BTMX[21]:B BTMX[22]:B BTMX[23]:B BTMX[24]:B BTMX[25]:B
*.pininfo BTMX[26]:B BTMX[27]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B BTMX[31]:B
*.pininfo GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B
*.pininfo GBW[7]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B
*.pininfo GD[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B
*.pininfo GRD0[6]:B GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B
*.pininfo GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B
*.pininfo GRD0[18]:B GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B
*.pininfo GRD0[24]:B GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B
*.pininfo GRD0[30]:B GRD0[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B
*.pininfo GRD1[4]:B GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B
*.pininfo GRD1[10]:B GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B
*.pininfo GRD1[16]:B GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B
*.pininfo GRD1[22]:B GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B
*.pininfo GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B
*.pininfo GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B
*.pininfo GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B
*.pininfo GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B
*.pininfo GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B
*.pininfo GRD3[6]:B GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B
*.pininfo GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B
*.pininfo GRD3[18]:B GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B
*.pininfo GRD3[24]:B GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B
*.pininfo GRD3[30]:B GRD3[31]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDB[4]:B
*.pininfo LDB[5]:B LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B
*.pininfo LDB[12]:B LDB[13]:B LDB[14]:B LDB[15]:B LDB[16]:B LDB[17]:B
*.pininfo LDB[18]:B LDB[19]:B LDB[20]:B LDB[21]:B LDB[22]:B LDB[23]:B
*.pininfo LDB[24]:B LDB[25]:B LDB[26]:B LDB[27]:B LDB[28]:B LDB[29]:B
*.pininfo LDB[30]:B LDB[31]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B LDT[4]:B
*.pininfo LDT[5]:B LDT[6]:B LDT[7]:B LDT[8]:B LDT[9]:B LDT[10]:B LDT[11]:B
*.pininfo LDT[12]:B LDT[13]:B LDT[14]:B LDT[15]:B LDT[16]:B LDT[17]:B
*.pininfo LDT[18]:B LDT[19]:B LDT[20]:B LDT[21]:B LDT[22]:B LDT[23]:B
*.pininfo LDT[24]:B LDT[25]:B LDT[26]:B LDT[27]:B LDT[28]:B LDT[29]:B
*.pininfo LDT[30]:B LDT[31]:B RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B RBBMX[3]:B
*.pininfo RBTMX[0]:B RBTMX[1]:B RBTMX[2]:B RBTMX[3]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B
*.pininfo RGRD3[2]:B RGRD3[3]:B RLDB[0]:B RLDB[1]:B RLDB[2]:B RLDB[3]:B
*.pininfo RLDT[0]:B RLDT[1]:B RLDT[2]:B RLDT[3]:B VSSX:B RGD:B RGBW:B
*.pininfo BBR[0]:B BBR[1]:B BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B
*.pininfo BBR[7]:B BBR[8]:B BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B
*.pininfo BBR[14]:B BBR[15]:B BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B
*.pininfo BBR[20]:B BBR[21]:B BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B
*.pininfo BBR[26]:B BBR[27]:B BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B
*.pininfo BBR[32]:B BBR[33]:B BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B
*.pininfo BBR[38]:B BBR[39]:B BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B
*.pininfo BBR[44]:B BBR[45]:B BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B
*.pininfo BBR[50]:B BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B
*.pininfo BBR[56]:B BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B
*.pininfo BBR[62]:B BBR[63]:B BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B
*.pininfo BBR[68]:B BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B
*.pininfo BBR[74]:B BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B
*.pininfo BBR[80]:B BBR[81]:B BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B
*.pininfo BBR[86]:B BBR[87]:B BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B
*.pininfo BBR[92]:B BBR[93]:B BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B
*.pininfo BBR[98]:B BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B
*.pininfo BBR[104]:B BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B
*.pininfo BBR[110]:B BBR[111]:B BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B
*.pininfo BBR[116]:B BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B
*.pininfo BBR[122]:B BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B
*.pininfo BTR[0]:B BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B
*.pininfo BTR[7]:B BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B
*.pininfo BTR[14]:B BTR[15]:B BTR[16]:B BTR[17]:B BTR[18]:B BTR[19]:B
*.pininfo BTR[20]:B BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B BTR[25]:B
*.pininfo BTR[26]:B BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B BTR[31]:B
*.pininfo BTR[32]:B BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B BTR[37]:B
*.pininfo BTR[38]:B BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B BTR[43]:B
*.pininfo BTR[44]:B BTR[45]:B BTR[46]:B BTR[47]:B BTR[48]:B BTR[49]:B
*.pininfo BTR[50]:B BTR[51]:B BTR[52]:B BTR[53]:B BTR[54]:B BTR[55]:B
*.pininfo BTR[56]:B BTR[57]:B BTR[58]:B BTR[59]:B BTR[60]:B BTR[61]:B
*.pininfo BTR[62]:B BTR[63]:B BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B
*.pininfo BTR[68]:B BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B
*.pininfo BTR[74]:B BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B
*.pininfo BTR[80]:B BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B BTR[85]:B
*.pininfo BTR[86]:B BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B BTR[91]:B
*.pininfo BTR[92]:B BTR[93]:B BTR[94]:B BTR[95]:B BTR[96]:B BTR[97]:B
*.pininfo BTR[98]:B BTR[99]:B BTR[100]:B BTR[101]:B BTR[102]:B BTR[103]:B
*.pininfo BTR[104]:B BTR[105]:B BTR[106]:B BTR[107]:B BTR[108]:B BTR[109]:B
*.pininfo BTR[110]:B BTR[111]:B BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B
*.pininfo BTR[116]:B BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B
*.pininfo BTR[122]:B BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B
*.pininfo RBB_R[0]:B RBB_R[1]:B RBB_R[2]:B RBB_R[3]:B RBB_R[4]:B RBB_R[5]:B
*.pininfo RBB_R[6]:B RBB_R[7]:B RBB_R[8]:B RBB_R[9]:B RBB_R[10]:B RBB_R[11]:B
*.pininfo RBB_R[12]:B RBB_R[13]:B RBB_R[14]:B RBB_R[15]:B RBT_R[0]:B
*.pininfo RBT_R[1]:B RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B RBT_R[5]:B RBT_R[6]:B
*.pininfo RBT_R[7]:B RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B RBT_R[11]:B
*.pininfo RBT_R[12]:B RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B
XXspram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA_0 PWR VDDA VSS SPU BPU AG SB[1]
+ SB[2] SB[3] SB[4] VNW RBS[0] RBS[1] RBS[2] RBS[3] WBS[0] WBS[1] WBS[2]
+ WBS[3] CS[0] CS[1] CS[2] CS[3] WM[0] WM[1] WM[2] SAET BSTB SAPR VSSX LDB[0]
+ LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9] LDB[10]
+ LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18] LDB[19]
+ LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27] LDB[28]
+ LDB[29] LDB[30] LDB[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5]
+ GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6]
+ BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13] BBMX[14]
+ BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21] BBMX[22]
+ BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29] BBMX[30]
+ BBMX[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9]
+ LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18]
+ LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27]
+ LDT[28] LDT[29] LDT[30] LDT[31] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6]
+ GD[7] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] BTMX[0]
+ BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9]
+ BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16] BTMX[17]
+ BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24] BTMX[25]
+ BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30] BTMX[31] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10]
+ GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26]
+ GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] BBR[0] BBR[1] BBR[2] BBR[3] BBR[4]
+ BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14]
+ BBR[15] BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23]
+ BBR[24] BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50]
+ BBR[51] BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59]
+ BBR[60] BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68]
+ BBR[69] BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77]
+ BBR[78] BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86]
+ BBR[87] BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95]
+ BBR[96] BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103]
+ BBR[104] BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111]
+ BBR[112] BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119]
+ BBR[120] BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127]
+ BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9]
+ BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18]
+ BTR[19] BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27]
+ BTR[28] BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36]
+ BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45]
+ BTR[46] BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ BTR[64] BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72]
+ BTR[73] BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81]
+ BTR[82] BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90]
+ BTR[91] BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99]
+ BTR[100] BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107]
+ BTR[108] BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127] RLDB[0] RLDB[1] RLDB[2] RLDB[3]
+ RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3]
+ RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RLDT[0] RLDT[1] RLDT[2] RLDT[3] RGD
+ RGBW RBTMX[0] RBTMX[1] RBTMX[2] RBTMX[3] RGRD1[0] RGRD1[1] RGRD1[2]
+ RGRD1[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RBB_R[0] RBB_R[1] RBB_R[2]
+ RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10]
+ RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1]
+ RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9]
+ RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15]
+ spram_4096x16m16b1pm2re1PM2M16B1ARLARRAYA m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1ARL

.subckt spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_L BBMX[32] BBMX[33]
+ BBMX[34] BBMX[35] BBMX[36] BBMX[37] BBMX[38] BBMX[39] BBMX[40] BBMX[41]
+ BBMX[42] BBMX[43] BBMX[44] BBMX[45] BBMX[46] BBMX[47] BBMX[48] BBMX[49]
+ BBMX[50] BBMX[51] BBMX[52] BBMX[53] BBMX[54] BBMX[55] BBMX[56] BBMX[57]
+ BBMX[58] BBMX[59] BBMX[60] BBMX[61] BBMX[62] BBMX[63] BTMX[32] BTMX[33]
+ BTMX[34] BTMX[35] BTMX[36] BTMX[37] BTMX[38] BTMX[39] BTMX[40] BTMX[41]
+ BTMX[42] BTMX[43] BTMX[44] BTMX[45] BTMX[46] BTMX[47] BTMX[48] BTMX[49]
+ BTMX[50] BTMX[51] BTMX[52] BTMX[53] BTMX[54] BTMX[55] BTMX[56] BTMX[57]
+ BTMX[58] BTMX[59] BTMX[60] BTMX[61] BTMX[62] BTMX[63] GBW[8] GBW[9] GBW[10]
+ GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12]
+ GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37]
+ GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45]
+ GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53]
+ GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61]
+ GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37]
+ GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45]
+ GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53]
+ GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61]
+ GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37]
+ GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45]
+ GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53]
+ GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61]
+ GRD3[62] GRD3[63] LDB[32] LDB[33] LDB[34] LDB[35] LDB[36] LDB[37] LDB[38]
+ LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44] LDB[45] LDB[46] LDB[47]
+ LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53] LDB[54] LDB[55] LDB[56]
+ LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62] LDB[63] LDT[32] LDT[33]
+ LDT[34] LDT[35] LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42]
+ LDT[43] LDT[44] LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51]
+ LDT[52] LDT[53] LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60]
+ LDT[61] LDT[62] LDT[63] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0]
+ RBTMX[1] RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0]
+ RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0]
+ RGRD3[1] RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1]
+ RLDT[2] RLDT[3] VSS VDDA PWR VSSX RGD RGBW BBR[128] BBR[129] BBR[130]
+ BBR[131] BBR[132] BBR[133] BBR[134] BBR[135] BBR[136] BBR[137] BBR[138]
+ BBR[139] BBR[140] BBR[141] BBR[142] BBR[143] BBR[144] BBR[145] BBR[146]
+ BBR[147] BBR[148] BBR[149] BBR[150] BBR[151] BBR[152] BBR[153] BBR[154]
+ BBR[155] BBR[156] BBR[157] BBR[158] BBR[159] BBR[160] BBR[161] BBR[162]
+ BBR[163] BBR[164] BBR[165] BBR[166] BBR[167] BBR[168] BBR[169] BBR[170]
+ BBR[171] BBR[172] BBR[173] BBR[174] BBR[175] BBR[176] BBR[177] BBR[178]
+ BBR[179] BBR[180] BBR[181] BBR[182] BBR[183] BBR[184] BBR[185] BBR[186]
+ BBR[187] BBR[188] BBR[189] BBR[190] BBR[191] BBR[192] BBR[193] BBR[194]
+ BBR[195] BBR[196] BBR[197] BBR[198] BBR[199] BBR[200] BBR[201] BBR[202]
+ BBR[203] BBR[204] BBR[205] BBR[206] BBR[207] BBR[208] BBR[209] BBR[210]
+ BBR[211] BBR[212] BBR[213] BBR[214] BBR[215] BBR[216] BBR[217] BBR[218]
+ BBR[219] BBR[220] BBR[221] BBR[222] BBR[223] BBR[224] BBR[225] BBR[226]
+ BBR[227] BBR[228] BBR[229] BBR[230] BBR[231] BBR[232] BBR[233] BBR[234]
+ BBR[235] BBR[236] BBR[237] BBR[238] BBR[239] BBR[240] BBR[241] BBR[242]
+ BBR[243] BBR[244] BBR[245] BBR[246] BBR[247] BBR[248] BBR[249] BBR[250]
+ BBR[251] BBR[252] BBR[253] BBR[254] BBR[255] BTR[128] BTR[129] BTR[130]
+ BTR[131] BTR[132] BTR[133] BTR[134] BTR[135] BTR[136] BTR[137] BTR[138]
+ BTR[139] BTR[140] BTR[141] BTR[142] BTR[143] BTR[144] BTR[145] BTR[146]
+ BTR[147] BTR[148] BTR[149] BTR[150] BTR[151] BTR[152] BTR[153] BTR[154]
+ BTR[155] BTR[156] BTR[157] BTR[158] BTR[159] BTR[160] BTR[161] BTR[162]
+ BTR[163] BTR[164] BTR[165] BTR[166] BTR[167] BTR[168] BTR[169] BTR[170]
+ BTR[171] BTR[172] BTR[173] BTR[174] BTR[175] BTR[176] BTR[177] BTR[178]
+ BTR[179] BTR[180] BTR[181] BTR[182] BTR[183] BTR[184] BTR[185] BTR[186]
+ BTR[187] BTR[188] BTR[189] BTR[190] BTR[191] BTR[192] BTR[193] BTR[194]
+ BTR[195] BTR[196] BTR[197] BTR[198] BTR[199] BTR[200] BTR[201] BTR[202]
+ BTR[203] BTR[204] BTR[205] BTR[206] BTR[207] BTR[208] BTR[209] BTR[210]
+ BTR[211] BTR[212] BTR[213] BTR[214] BTR[215] BTR[216] BTR[217] BTR[218]
+ BTR[219] BTR[220] BTR[221] BTR[222] BTR[223] BTR[224] BTR[225] BTR[226]
+ BTR[227] BTR[228] BTR[229] BTR[230] BTR[231] BTR[232] BTR[233] BTR[234]
+ BTR[235] BTR[236] BTR[237] BTR[238] BTR[239] BTR[240] BTR[241] BTR[242]
+ BTR[243] BTR[244] BTR[245] BTR[246] BTR[247] BTR[248] BTR[249] BTR[250]
+ BTR[251] BTR[252] BTR[253] BTR[254] BTR[255] RBB_R[0] RBB_R[1] RBB_R[2]
+ RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10]
+ RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1]
+ RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9]
+ RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15] CSC[0] CSC[1]
+ CSC[2] CSC[3] RBSC[0] RBSC[1] RBSC[2] RBSC[3] SBC[1] SBC[2] SBC[3] SBC[4]
+ WBSC[0] WBSC[1] WBSC[2] WBSC[3] WMHC[0] WMHC[1] WMHC[2] SPUC BPUC AGC VNW
+ SAETC BSTBC SAPRC
*.pininfo BBMX[32]:B BBMX[33]:B BBMX[34]:B BBMX[35]:B BBMX[36]:B BBMX[37]:B
*.pininfo BBMX[38]:B BBMX[39]:B BBMX[40]:B BBMX[41]:B BBMX[42]:B BBMX[43]:B
*.pininfo BBMX[44]:B BBMX[45]:B BBMX[46]:B BBMX[47]:B BBMX[48]:B BBMX[49]:B
*.pininfo BBMX[50]:B BBMX[51]:B BBMX[52]:B BBMX[53]:B BBMX[54]:B BBMX[55]:B
*.pininfo BBMX[56]:B BBMX[57]:B BBMX[58]:B BBMX[59]:B BBMX[60]:B BBMX[61]:B
*.pininfo BBMX[62]:B BBMX[63]:B BTMX[32]:B BTMX[33]:B BTMX[34]:B BTMX[35]:B
*.pininfo BTMX[36]:B BTMX[37]:B BTMX[38]:B BTMX[39]:B BTMX[40]:B BTMX[41]:B
*.pininfo BTMX[42]:B BTMX[43]:B BTMX[44]:B BTMX[45]:B BTMX[46]:B BTMX[47]:B
*.pininfo BTMX[48]:B BTMX[49]:B BTMX[50]:B BTMX[51]:B BTMX[52]:B BTMX[53]:B
*.pininfo BTMX[54]:B BTMX[55]:B BTMX[56]:B BTMX[57]:B BTMX[58]:B BTMX[59]:B
*.pininfo BTMX[60]:B BTMX[61]:B BTMX[62]:B BTMX[63]:B GBW[8]:B GBW[9]:B
*.pininfo GBW[10]:B GBW[11]:B GBW[12]:B GBW[13]:B GBW[14]:B GBW[15]:B GD[8]:B
*.pininfo GD[9]:B GD[10]:B GD[11]:B GD[12]:B GD[13]:B GD[14]:B GD[15]:B
*.pininfo GRD0[32]:B GRD0[33]:B GRD0[34]:B GRD0[35]:B GRD0[36]:B GRD0[37]:B
*.pininfo GRD0[38]:B GRD0[39]:B GRD0[40]:B GRD0[41]:B GRD0[42]:B GRD0[43]:B
*.pininfo GRD0[44]:B GRD0[45]:B GRD0[46]:B GRD0[47]:B GRD0[48]:B GRD0[49]:B
*.pininfo GRD0[50]:B GRD0[51]:B GRD0[52]:B GRD0[53]:B GRD0[54]:B GRD0[55]:B
*.pininfo GRD0[56]:B GRD0[57]:B GRD0[58]:B GRD0[59]:B GRD0[60]:B GRD0[61]:B
*.pininfo GRD0[62]:B GRD0[63]:B GRD1[32]:B GRD1[33]:B GRD1[34]:B GRD1[35]:B
*.pininfo GRD1[36]:B GRD1[37]:B GRD1[38]:B GRD1[39]:B GRD1[40]:B GRD1[41]:B
*.pininfo GRD1[42]:B GRD1[43]:B GRD1[44]:B GRD1[45]:B GRD1[46]:B GRD1[47]:B
*.pininfo GRD1[48]:B GRD1[49]:B GRD1[50]:B GRD1[51]:B GRD1[52]:B GRD1[53]:B
*.pininfo GRD1[54]:B GRD1[55]:B GRD1[56]:B GRD1[57]:B GRD1[58]:B GRD1[59]:B
*.pininfo GRD1[60]:B GRD1[61]:B GRD1[62]:B GRD1[63]:B GRD2[32]:B GRD2[33]:B
*.pininfo GRD2[34]:B GRD2[35]:B GRD2[36]:B GRD2[37]:B GRD2[38]:B GRD2[39]:B
*.pininfo GRD2[40]:B GRD2[41]:B GRD2[42]:B GRD2[43]:B GRD2[44]:B GRD2[45]:B
*.pininfo GRD2[46]:B GRD2[47]:B GRD2[48]:B GRD2[49]:B GRD2[50]:B GRD2[51]:B
*.pininfo GRD2[52]:B GRD2[53]:B GRD2[54]:B GRD2[55]:B GRD2[56]:B GRD2[57]:B
*.pininfo GRD2[58]:B GRD2[59]:B GRD2[60]:B GRD2[61]:B GRD2[62]:B GRD2[63]:B
*.pininfo GRD3[32]:B GRD3[33]:B GRD3[34]:B GRD3[35]:B GRD3[36]:B GRD3[37]:B
*.pininfo GRD3[38]:B GRD3[39]:B GRD3[40]:B GRD3[41]:B GRD3[42]:B GRD3[43]:B
*.pininfo GRD3[44]:B GRD3[45]:B GRD3[46]:B GRD3[47]:B GRD3[48]:B GRD3[49]:B
*.pininfo GRD3[50]:B GRD3[51]:B GRD3[52]:B GRD3[53]:B GRD3[54]:B GRD3[55]:B
*.pininfo GRD3[56]:B GRD3[57]:B GRD3[58]:B GRD3[59]:B GRD3[60]:B GRD3[61]:B
*.pininfo GRD3[62]:B GRD3[63]:B LDB[32]:B LDB[33]:B LDB[34]:B LDB[35]:B
*.pininfo LDB[36]:B LDB[37]:B LDB[38]:B LDB[39]:B LDB[40]:B LDB[41]:B
*.pininfo LDB[42]:B LDB[43]:B LDB[44]:B LDB[45]:B LDB[46]:B LDB[47]:B
*.pininfo LDB[48]:B LDB[49]:B LDB[50]:B LDB[51]:B LDB[52]:B LDB[53]:B
*.pininfo LDB[54]:B LDB[55]:B LDB[56]:B LDB[57]:B LDB[58]:B LDB[59]:B
*.pininfo LDB[60]:B LDB[61]:B LDB[62]:B LDB[63]:B LDT[32]:B LDT[33]:B
*.pininfo LDT[34]:B LDT[35]:B LDT[36]:B LDT[37]:B LDT[38]:B LDT[39]:B
*.pininfo LDT[40]:B LDT[41]:B LDT[42]:B LDT[43]:B LDT[44]:B LDT[45]:B
*.pininfo LDT[46]:B LDT[47]:B LDT[48]:B LDT[49]:B LDT[50]:B LDT[51]:B
*.pininfo LDT[52]:B LDT[53]:B LDT[54]:B LDT[55]:B LDT[56]:B LDT[57]:B
*.pininfo LDT[58]:B LDT[59]:B LDT[60]:B LDT[61]:B LDT[62]:B LDT[63]:B
*.pininfo RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B RBBMX[3]:B RBTMX[0]:B RBTMX[1]:B
*.pininfo RBTMX[2]:B RBTMX[3]:B RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B
*.pininfo RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD2[0]:B RGRD2[1]:B
*.pininfo RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B
*.pininfo RLDB[0]:B RLDB[1]:B RLDB[2]:B RLDB[3]:B RLDT[0]:B RLDT[1]:B
*.pininfo RLDT[2]:B RLDT[3]:B VSS:B VDDA:B PWR:B VSSX:B RGD:B RGBW:B
*.pininfo BBR[128]:B BBR[129]:B BBR[130]:B BBR[131]:B BBR[132]:B BBR[133]:B
*.pininfo BBR[134]:B BBR[135]:B BBR[136]:B BBR[137]:B BBR[138]:B BBR[139]:B
*.pininfo BBR[140]:B BBR[141]:B BBR[142]:B BBR[143]:B BBR[144]:B BBR[145]:B
*.pininfo BBR[146]:B BBR[147]:B BBR[148]:B BBR[149]:B BBR[150]:B BBR[151]:B
*.pininfo BBR[152]:B BBR[153]:B BBR[154]:B BBR[155]:B BBR[156]:B BBR[157]:B
*.pininfo BBR[158]:B BBR[159]:B BBR[160]:B BBR[161]:B BBR[162]:B BBR[163]:B
*.pininfo BBR[164]:B BBR[165]:B BBR[166]:B BBR[167]:B BBR[168]:B BBR[169]:B
*.pininfo BBR[170]:B BBR[171]:B BBR[172]:B BBR[173]:B BBR[174]:B BBR[175]:B
*.pininfo BBR[176]:B BBR[177]:B BBR[178]:B BBR[179]:B BBR[180]:B BBR[181]:B
*.pininfo BBR[182]:B BBR[183]:B BBR[184]:B BBR[185]:B BBR[186]:B BBR[187]:B
*.pininfo BBR[188]:B BBR[189]:B BBR[190]:B BBR[191]:B BBR[192]:B BBR[193]:B
*.pininfo BBR[194]:B BBR[195]:B BBR[196]:B BBR[197]:B BBR[198]:B BBR[199]:B
*.pininfo BBR[200]:B BBR[201]:B BBR[202]:B BBR[203]:B BBR[204]:B BBR[205]:B
*.pininfo BBR[206]:B BBR[207]:B BBR[208]:B BBR[209]:B BBR[210]:B BBR[211]:B
*.pininfo BBR[212]:B BBR[213]:B BBR[214]:B BBR[215]:B BBR[216]:B BBR[217]:B
*.pininfo BBR[218]:B BBR[219]:B BBR[220]:B BBR[221]:B BBR[222]:B BBR[223]:B
*.pininfo BBR[224]:B BBR[225]:B BBR[226]:B BBR[227]:B BBR[228]:B BBR[229]:B
*.pininfo BBR[230]:B BBR[231]:B BBR[232]:B BBR[233]:B BBR[234]:B BBR[235]:B
*.pininfo BBR[236]:B BBR[237]:B BBR[238]:B BBR[239]:B BBR[240]:B BBR[241]:B
*.pininfo BBR[242]:B BBR[243]:B BBR[244]:B BBR[245]:B BBR[246]:B BBR[247]:B
*.pininfo BBR[248]:B BBR[249]:B BBR[250]:B BBR[251]:B BBR[252]:B BBR[253]:B
*.pininfo BBR[254]:B BBR[255]:B BTR[128]:B BTR[129]:B BTR[130]:B BTR[131]:B
*.pininfo BTR[132]:B BTR[133]:B BTR[134]:B BTR[135]:B BTR[136]:B BTR[137]:B
*.pininfo BTR[138]:B BTR[139]:B BTR[140]:B BTR[141]:B BTR[142]:B BTR[143]:B
*.pininfo BTR[144]:B BTR[145]:B BTR[146]:B BTR[147]:B BTR[148]:B BTR[149]:B
*.pininfo BTR[150]:B BTR[151]:B BTR[152]:B BTR[153]:B BTR[154]:B BTR[155]:B
*.pininfo BTR[156]:B BTR[157]:B BTR[158]:B BTR[159]:B BTR[160]:B BTR[161]:B
*.pininfo BTR[162]:B BTR[163]:B BTR[164]:B BTR[165]:B BTR[166]:B BTR[167]:B
*.pininfo BTR[168]:B BTR[169]:B BTR[170]:B BTR[171]:B BTR[172]:B BTR[173]:B
*.pininfo BTR[174]:B BTR[175]:B BTR[176]:B BTR[177]:B BTR[178]:B BTR[179]:B
*.pininfo BTR[180]:B BTR[181]:B BTR[182]:B BTR[183]:B BTR[184]:B BTR[185]:B
*.pininfo BTR[186]:B BTR[187]:B BTR[188]:B BTR[189]:B BTR[190]:B BTR[191]:B
*.pininfo BTR[192]:B BTR[193]:B BTR[194]:B BTR[195]:B BTR[196]:B BTR[197]:B
*.pininfo BTR[198]:B BTR[199]:B BTR[200]:B BTR[201]:B BTR[202]:B BTR[203]:B
*.pininfo BTR[204]:B BTR[205]:B BTR[206]:B BTR[207]:B BTR[208]:B BTR[209]:B
*.pininfo BTR[210]:B BTR[211]:B BTR[212]:B BTR[213]:B BTR[214]:B BTR[215]:B
*.pininfo BTR[216]:B BTR[217]:B BTR[218]:B BTR[219]:B BTR[220]:B BTR[221]:B
*.pininfo BTR[222]:B BTR[223]:B BTR[224]:B BTR[225]:B BTR[226]:B BTR[227]:B
*.pininfo BTR[228]:B BTR[229]:B BTR[230]:B BTR[231]:B BTR[232]:B BTR[233]:B
*.pininfo BTR[234]:B BTR[235]:B BTR[236]:B BTR[237]:B BTR[238]:B BTR[239]:B
*.pininfo BTR[240]:B BTR[241]:B BTR[242]:B BTR[243]:B BTR[244]:B BTR[245]:B
*.pininfo BTR[246]:B BTR[247]:B BTR[248]:B BTR[249]:B BTR[250]:B BTR[251]:B
*.pininfo BTR[252]:B BTR[253]:B BTR[254]:B BTR[255]:B RBB_R[0]:B RBB_R[1]:B
*.pininfo RBB_R[2]:B RBB_R[3]:B RBB_R[4]:B RBB_R[5]:B RBB_R[6]:B RBB_R[7]:B
*.pininfo RBB_R[8]:B RBB_R[9]:B RBB_R[10]:B RBB_R[11]:B RBB_R[12]:B
*.pininfo RBB_R[13]:B RBB_R[14]:B RBB_R[15]:B RBT_R[0]:B RBT_R[1]:B
*.pininfo RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B RBT_R[5]:B RBT_R[6]:B RBT_R[7]:B
*.pininfo RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B RBT_R[11]:B RBT_R[12]:B
*.pininfo RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B CSC[0]:B CSC[1]:B CSC[2]:B
*.pininfo CSC[3]:B RBSC[0]:B RBSC[1]:B RBSC[2]:B RBSC[3]:B SBC[1]:B SBC[2]:B
*.pininfo SBC[3]:B SBC[4]:B WBSC[0]:B WBSC[1]:B WBSC[2]:B WBSC[3]:B WMHC[0]:B
*.pininfo WMHC[1]:B WMHC[2]:B SPUC:B BPUC:B AGC:B VNW:B SAETC:B BSTBC:B
*.pininfo SAPRC:B
XXLIO_LOCIO_L VSS VDDA PWR CSC[0] CSC[1] CSC[2] CSC[3] RBSC[0] RBSC[1]
+ RBSC[2] RBSC[3] SBC[1] SBC[2] SBC[3] SBC[4] WBSC[0] WBSC[1] WBSC[2] WBSC[3]
+ WMHC[0] WMHC[1] WMHC[2] SPUC BPUC AGC VNW SAETC BSTBC SAPRC BBMX[32]
+ BBMX[33] BBMX[34] BBMX[35] BBMX[36] BBMX[37] BBMX[38] BBMX[39] BBMX[40]
+ BBMX[41] BBMX[42] BBMX[43] BBMX[44] BBMX[45] BBMX[46] BBMX[47] BBMX[48]
+ BBMX[49] BBMX[50] BBMX[51] BBMX[52] BBMX[53] BBMX[54] BBMX[55] BBMX[56]
+ BBMX[57] BBMX[58] BBMX[59] BBMX[60] BBMX[61] BBMX[62] BBMX[63] BTMX[32]
+ BTMX[33] BTMX[34] BTMX[35] BTMX[36] BTMX[37] BTMX[38] BTMX[39] BTMX[40]
+ BTMX[41] BTMX[42] BTMX[43] BTMX[44] BTMX[45] BTMX[46] BTMX[47] BTMX[48]
+ BTMX[49] BTMX[50] BTMX[51] BTMX[52] BTMX[53] BTMX[54] BTMX[55] BTMX[56]
+ BTMX[57] BTMX[58] BTMX[59] BTMX[60] BTMX[61] BTMX[62] BTMX[63] GBW[8]
+ GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10]
+ GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35]
+ GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43]
+ GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51]
+ GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59]
+ GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35]
+ GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43]
+ GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51]
+ GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59]
+ GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35]
+ GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43]
+ GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51]
+ GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59]
+ GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35]
+ GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43]
+ GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51]
+ GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59]
+ GRD3[60] GRD3[61] GRD3[62] GRD3[63] LDB[32] LDB[33] LDB[34] LDB[35] LDB[36]
+ LDB[37] LDB[38] LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44] LDB[45]
+ LDB[46] LDB[47] LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53] LDB[54]
+ LDB[55] LDB[56] LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62] LDB[63]
+ LDT[32] LDT[33] LDT[34] LDT[35] LDT[36] LDT[37] LDT[38] LDT[39] LDT[40]
+ LDT[41] LDT[42] LDT[43] LDT[44] LDT[45] LDT[46] LDT[47] LDT[48] LDT[49]
+ LDT[50] LDT[51] LDT[52] LDT[53] LDT[54] LDT[55] LDT[56] LDT[57] LDT[58]
+ LDT[59] LDT[60] LDT[61] LDT[62] LDT[63] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3]
+ RBTMX[0] RBTMX[1] RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3]
+ RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3]
+ RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0]
+ RLDT[1] RLDT[2] RLDT[3] VSSX RGD RGBW BBR[128] BBR[129] BBR[130] BBR[131]
+ BBR[132] BBR[133] BBR[134] BBR[135] BBR[136] BBR[137] BBR[138] BBR[139]
+ BBR[140] BBR[141] BBR[142] BBR[143] BBR[144] BBR[145] BBR[146] BBR[147]
+ BBR[148] BBR[149] BBR[150] BBR[151] BBR[152] BBR[153] BBR[154] BBR[155]
+ BBR[156] BBR[157] BBR[158] BBR[159] BBR[160] BBR[161] BBR[162] BBR[163]
+ BBR[164] BBR[165] BBR[166] BBR[167] BBR[168] BBR[169] BBR[170] BBR[171]
+ BBR[172] BBR[173] BBR[174] BBR[175] BBR[176] BBR[177] BBR[178] BBR[179]
+ BBR[180] BBR[181] BBR[182] BBR[183] BBR[184] BBR[185] BBR[186] BBR[187]
+ BBR[188] BBR[189] BBR[190] BBR[191] BBR[192] BBR[193] BBR[194] BBR[195]
+ BBR[196] BBR[197] BBR[198] BBR[199] BBR[200] BBR[201] BBR[202] BBR[203]
+ BBR[204] BBR[205] BBR[206] BBR[207] BBR[208] BBR[209] BBR[210] BBR[211]
+ BBR[212] BBR[213] BBR[214] BBR[215] BBR[216] BBR[217] BBR[218] BBR[219]
+ BBR[220] BBR[221] BBR[222] BBR[223] BBR[224] BBR[225] BBR[226] BBR[227]
+ BBR[228] BBR[229] BBR[230] BBR[231] BBR[232] BBR[233] BBR[234] BBR[235]
+ BBR[236] BBR[237] BBR[238] BBR[239] BBR[240] BBR[241] BBR[242] BBR[243]
+ BBR[244] BBR[245] BBR[246] BBR[247] BBR[248] BBR[249] BBR[250] BBR[251]
+ BBR[252] BBR[253] BBR[254] BBR[255] BTR[128] BTR[129] BTR[130] BTR[131]
+ BTR[132] BTR[133] BTR[134] BTR[135] BTR[136] BTR[137] BTR[138] BTR[139]
+ BTR[140] BTR[141] BTR[142] BTR[143] BTR[144] BTR[145] BTR[146] BTR[147]
+ BTR[148] BTR[149] BTR[150] BTR[151] BTR[152] BTR[153] BTR[154] BTR[155]
+ BTR[156] BTR[157] BTR[158] BTR[159] BTR[160] BTR[161] BTR[162] BTR[163]
+ BTR[164] BTR[165] BTR[166] BTR[167] BTR[168] BTR[169] BTR[170] BTR[171]
+ BTR[172] BTR[173] BTR[174] BTR[175] BTR[176] BTR[177] BTR[178] BTR[179]
+ BTR[180] BTR[181] BTR[182] BTR[183] BTR[184] BTR[185] BTR[186] BTR[187]
+ BTR[188] BTR[189] BTR[190] BTR[191] BTR[192] BTR[193] BTR[194] BTR[195]
+ BTR[196] BTR[197] BTR[198] BTR[199] BTR[200] BTR[201] BTR[202] BTR[203]
+ BTR[204] BTR[205] BTR[206] BTR[207] BTR[208] BTR[209] BTR[210] BTR[211]
+ BTR[212] BTR[213] BTR[214] BTR[215] BTR[216] BTR[217] BTR[218] BTR[219]
+ BTR[220] BTR[221] BTR[222] BTR[223] BTR[224] BTR[225] BTR[226] BTR[227]
+ BTR[228] BTR[229] BTR[230] BTR[231] BTR[232] BTR[233] BTR[234] BTR[235]
+ BTR[236] BTR[237] BTR[238] BTR[239] BTR[240] BTR[241] BTR[242] BTR[243]
+ BTR[244] BTR[245] BTR[246] BTR[247] BTR[248] BTR[249] BTR[250] BTR[251]
+ BTR[252] BTR[253] BTR[254] BTR[255] RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3]
+ RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11]
+ RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3]
+ RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11]
+ RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15]
+ spram_4096x16m16b1pm2re1PM2M16B1ARL m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_L

.subckt spram_4096x16m16b1pm2re1PM2M16B1LIO BBMX[0] BBMX[1] BBMX[2] BBMX[3]
+ BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12]
+ BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20]
+ BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28]
+ BBMX[29] BBMX[30] BBMX[31] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5]
+ BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9]
+ LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18]
+ LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27]
+ LDB[28] LDB[29] LDB[30] LDB[31] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5]
+ LDT[6] LDT[7] LDT[8] LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15]
+ LDT[16] LDT[17] LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24]
+ LDT[25] LDT[26] LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] VSS VDDA PWR VSSX
+ BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9]
+ BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBR[16] BBR[17] BBR[18]
+ BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27]
+ BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33] BBR[34] BBR[35] BBR[36]
+ BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44] BBR[45]
+ BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52] BBR[53] BBR[54]
+ BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61] BBR[62] BBR[63]
+ BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71] BBR[72]
+ BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96] BBR[97] BBR[98] BBR[99]
+ BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107]
+ BBR[108] BBR[109] BBR[110] BBR[111] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4]
+ BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14]
+ BTR[15] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22] BTR[23]
+ BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31] BTR[32]
+ BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41]
+ BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] BTR[48] BTR[49] BTR[50]
+ BTR[51] BTR[52] BTR[53] BTR[54] BTR[55] BTR[56] BTR[57] BTR[58] BTR[59]
+ BTR[60] BTR[61] BTR[62] BTR[63] BTR[64] BTR[65] BTR[66] BTR[67] BTR[68]
+ BTR[69] BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76] BTR[77]
+ BTR[78] BTR[79] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85] BTR[86]
+ BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94] BTR[95]
+ BTR[96] BTR[97] BTR[98] BTR[99] BTR[100] BTR[101] BTR[102] BTR[103]
+ BTR[104] BTR[105] BTR[106] BTR[107] BTR[108] BTR[109] BTR[110] BTR[111]
+ BTR[112] BTR[113] BTR[114] BTR[115] BTR[116] BTR[117] BTR[118] BTR[119]
+ BTR[120] BTR[121] BTR[122] BTR[123] BTR[124] BTR[125] BTR[126] BTR[127]
+ XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3] CSH_LD XA[0] XA[1] XA[2]
+ XA[3] GRST WMO[0] WMO[1] WMO[2] CSH_RR ag_ctrl BPUI ZRR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] YSEL[0] YSEL[1]
+ YSEL[2] YSEL[3] LRST VSB[1] VSB[2] VSB[3] VSB[4] WLRST XWB[0] XWB[1] XWB[2]
+ XWB[3] RMO[0] RMO[1] RMO[2] VNW SPUI RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] EN CSH_ENB T0EN ENB DBL0 LCLKB XARMSBB_R[0] XARMSBB_R[1]
+ XARMSBB_R[2] XARMSBB_R[3] XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2]
+ XARLSBA_R[3] XZB[0] LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3] XARMSBA_R[0]
+ XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] BBMX[32] BBMX[33] BBMX[34] BBMX[35]
+ BBMX[36] BBMX[37] BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42] BBMX[43]
+ BBMX[44] BBMX[45] BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50] BBMX[51]
+ BBMX[52] BBMX[53] BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58] BBMX[59]
+ BBMX[60] BBMX[61] BBMX[62] BBMX[63] BTMX[32] BTMX[33] BTMX[34] BTMX[35]
+ BTMX[36] BTMX[37] BTMX[38] BTMX[39] BTMX[40] BTMX[41] BTMX[42] BTMX[43]
+ BTMX[44] BTMX[45] BTMX[46] BTMX[47] BTMX[48] BTMX[49] BTMX[50] BTMX[51]
+ BTMX[52] BTMX[53] BTMX[54] BTMX[55] BTMX[56] BTMX[57] BTMX[58] BTMX[59]
+ BTMX[60] BTMX[61] BTMX[62] BTMX[63] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12]
+ GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14]
+ GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37] GRD0[38]
+ GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45] GRD0[46]
+ GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53] GRD0[54]
+ GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61] GRD0[62]
+ GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38]
+ GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46]
+ GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54]
+ GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62]
+ GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38]
+ GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46]
+ GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54]
+ GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62]
+ GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] LDB[32] LDB[33] LDB[34] LDB[35] LDB[36] LDB[37] LDB[38] LDB[39]
+ LDB[40] LDB[41] LDB[42] LDB[43] LDB[44] LDB[45] LDB[46] LDB[47] LDB[48]
+ LDB[49] LDB[50] LDB[51] LDB[52] LDB[53] LDB[54] LDB[55] LDB[56] LDB[57]
+ LDB[58] LDB[59] LDB[60] LDB[61] LDB[62] LDB[63] LDT[32] LDT[33] LDT[34]
+ LDT[35] LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43]
+ LDT[44] LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52]
+ LDT[53] LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61]
+ LDT[62] LDT[63] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1]
+ RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2]
+ RLDT[3] RGD RGBW BBR[128] BBR[129] BBR[130] BBR[131] BBR[132] BBR[133]
+ BBR[134] BBR[135] BBR[136] BBR[137] BBR[138] BBR[139] BBR[140] BBR[141]
+ BBR[142] BBR[143] BBR[144] BBR[145] BBR[146] BBR[147] BBR[148] BBR[149]
+ BBR[150] BBR[151] BBR[152] BBR[153] BBR[154] BBR[155] BBR[156] BBR[157]
+ BBR[158] BBR[159] BBR[160] BBR[161] BBR[162] BBR[163] BBR[164] BBR[165]
+ BBR[166] BBR[167] BBR[168] BBR[169] BBR[170] BBR[171] BBR[172] BBR[173]
+ BBR[174] BBR[175] BBR[176] BBR[177] BBR[178] BBR[179] BBR[180] BBR[181]
+ BBR[182] BBR[183] BBR[184] BBR[185] BBR[186] BBR[187] BBR[188] BBR[189]
+ BBR[190] BBR[191] BBR[192] BBR[193] BBR[194] BBR[195] BBR[196] BBR[197]
+ BBR[198] BBR[199] BBR[200] BBR[201] BBR[202] BBR[203] BBR[204] BBR[205]
+ BBR[206] BBR[207] BBR[208] BBR[209] BBR[210] BBR[211] BBR[212] BBR[213]
+ BBR[214] BBR[215] BBR[216] BBR[217] BBR[218] BBR[219] BBR[220] BBR[221]
+ BBR[222] BBR[223] BBR[224] BBR[225] BBR[226] BBR[227] BBR[228] BBR[229]
+ BBR[230] BBR[231] BBR[232] BBR[233] BBR[234] BBR[235] BBR[236] BBR[237]
+ BBR[238] BBR[239] BBR[240] BBR[241] BBR[242] BBR[243] BBR[244] BBR[245]
+ BBR[246] BBR[247] BBR[248] BBR[249] BBR[250] BBR[251] BBR[252] BBR[253]
+ BBR[254] BBR[255] BTR[128] BTR[129] BTR[130] BTR[131] BTR[132] BTR[133]
+ BTR[134] BTR[135] BTR[136] BTR[137] BTR[138] BTR[139] BTR[140] BTR[141]
+ BTR[142] BTR[143] BTR[144] BTR[145] BTR[146] BTR[147] BTR[148] BTR[149]
+ BTR[150] BTR[151] BTR[152] BTR[153] BTR[154] BTR[155] BTR[156] BTR[157]
+ BTR[158] BTR[159] BTR[160] BTR[161] BTR[162] BTR[163] BTR[164] BTR[165]
+ BTR[166] BTR[167] BTR[168] BTR[169] BTR[170] BTR[171] BTR[172] BTR[173]
+ BTR[174] BTR[175] BTR[176] BTR[177] BTR[178] BTR[179] BTR[180] BTR[181]
+ BTR[182] BTR[183] BTR[184] BTR[185] BTR[186] BTR[187] BTR[188] BTR[189]
+ BTR[190] BTR[191] BTR[192] BTR[193] BTR[194] BTR[195] BTR[196] BTR[197]
+ BTR[198] BTR[199] BTR[200] BTR[201] BTR[202] BTR[203] BTR[204] BTR[205]
+ BTR[206] BTR[207] BTR[208] BTR[209] BTR[210] BTR[211] BTR[212] BTR[213]
+ BTR[214] BTR[215] BTR[216] BTR[217] BTR[218] BTR[219] BTR[220] BTR[221]
+ BTR[222] BTR[223] BTR[224] BTR[225] BTR[226] BTR[227] BTR[228] BTR[229]
+ BTR[230] BTR[231] BTR[232] BTR[233] BTR[234] BTR[235] BTR[236] BTR[237]
+ BTR[238] BTR[239] BTR[240] BTR[241] BTR[242] BTR[243] BTR[244] BTR[245]
+ BTR[246] BTR[247] BTR[248] BTR[249] BTR[250] BTR[251] BTR[252] BTR[253]
+ BTR[254] BTR[255] RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5]
+ RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13]
+ RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5]
+ RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13]
+ RBT_R[14] RBT_R[15]
*.pininfo BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B BBMX[16]:B BBMX[17]:B
*.pininfo BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B
*.pininfo BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B BBMX[28]:B BBMX[29]:B
*.pininfo BBMX[30]:B BBMX[31]:B BTMX[0]:B BTMX[1]:B BTMX[2]:B BTMX[3]:B
*.pininfo BTMX[4]:B BTMX[5]:B BTMX[6]:B BTMX[7]:B BTMX[8]:B BTMX[9]:B
*.pininfo BTMX[10]:B BTMX[11]:B BTMX[12]:B BTMX[13]:B BTMX[14]:B BTMX[15]:B
*.pininfo BTMX[16]:B BTMX[17]:B BTMX[18]:B BTMX[19]:B BTMX[20]:B BTMX[21]:B
*.pininfo BTMX[22]:B BTMX[23]:B BTMX[24]:B BTMX[25]:B BTMX[26]:B BTMX[27]:B
*.pininfo BTMX[28]:B BTMX[29]:B BTMX[30]:B BTMX[31]:B GBW[0]:B GBW[1]:B
*.pininfo GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B
*.pininfo GD[1]:B GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B
*.pininfo GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B
*.pininfo GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B
*.pininfo GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B
*.pininfo GRD0[31]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B
*.pininfo GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B
*.pininfo GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B
*.pininfo GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B
*.pininfo GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B
*.pininfo GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B
*.pininfo GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B
*.pininfo GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B
*.pininfo GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B
*.pininfo GRD3[31]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDB[4]:B LDB[5]:B
*.pininfo LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B LDB[12]:B
*.pininfo LDB[13]:B LDB[14]:B LDB[15]:B LDB[16]:B LDB[17]:B LDB[18]:B
*.pininfo LDB[19]:B LDB[20]:B LDB[21]:B LDB[22]:B LDB[23]:B LDB[24]:B
*.pininfo LDB[25]:B LDB[26]:B LDB[27]:B LDB[28]:B LDB[29]:B LDB[30]:B
*.pininfo LDB[31]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B LDT[4]:B LDT[5]:B
*.pininfo LDT[6]:B LDT[7]:B LDT[8]:B LDT[9]:B LDT[10]:B LDT[11]:B LDT[12]:B
*.pininfo LDT[13]:B LDT[14]:B LDT[15]:B LDT[16]:B LDT[17]:B LDT[18]:B
*.pininfo LDT[19]:B LDT[20]:B LDT[21]:B LDT[22]:B LDT[23]:B LDT[24]:B
*.pininfo LDT[25]:B LDT[26]:B LDT[27]:B LDT[28]:B LDT[29]:B LDT[30]:B
*.pininfo LDT[31]:B VSS:B VDDA:B PWR:B VSSX:B BBR[0]:B BBR[1]:B BBR[2]:B
*.pininfo BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B BBR[8]:B BBR[9]:B
*.pininfo BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B BBR[15]:B
*.pininfo BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B BBR[21]:B
*.pininfo BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B BBR[27]:B
*.pininfo BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B BBR[32]:B BBR[33]:B
*.pininfo BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B BBR[39]:B
*.pininfo BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B BBR[45]:B
*.pininfo BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B BBR[50]:B BBR[51]:B
*.pininfo BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B BBR[57]:B
*.pininfo BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B BBR[63]:B
*.pininfo BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B BBR[68]:B BBR[69]:B
*.pininfo BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B BBR[74]:B BBR[75]:B
*.pininfo BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B BBR[80]:B BBR[81]:B
*.pininfo BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B BBR[87]:B
*.pininfo BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B BBR[93]:B
*.pininfo BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B BBR[98]:B BBR[99]:B
*.pininfo BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B BBR[105]:B
*.pininfo BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B BBR[111]:B
*.pininfo BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B BBR[116]:B BBR[117]:B
*.pininfo BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B BBR[122]:B BBR[123]:B
*.pininfo BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B BTR[0]:B BTR[1]:B
*.pininfo BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B BTR[6]:B BTR[7]:B BTR[8]:B
*.pininfo BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B BTR[13]:B BTR[14]:B
*.pininfo BTR[15]:B BTR[16]:B BTR[17]:B BTR[18]:B BTR[19]:B BTR[20]:B
*.pininfo BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B BTR[25]:B BTR[26]:B
*.pininfo BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B BTR[31]:B BTR[32]:B
*.pininfo BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B BTR[37]:B BTR[38]:B
*.pininfo BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B BTR[43]:B BTR[44]:B
*.pininfo BTR[45]:B BTR[46]:B BTR[47]:B BTR[48]:B BTR[49]:B BTR[50]:B
*.pininfo BTR[51]:B BTR[52]:B BTR[53]:B BTR[54]:B BTR[55]:B BTR[56]:B
*.pininfo BTR[57]:B BTR[58]:B BTR[59]:B BTR[60]:B BTR[61]:B BTR[62]:B
*.pininfo BTR[63]:B BTR[64]:B BTR[65]:B BTR[66]:B BTR[67]:B BTR[68]:B
*.pininfo BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B BTR[73]:B BTR[74]:B
*.pininfo BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B BTR[79]:B BTR[80]:B
*.pininfo BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B BTR[85]:B BTR[86]:B
*.pininfo BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B BTR[91]:B BTR[92]:B
*.pininfo BTR[93]:B BTR[94]:B BTR[95]:B BTR[96]:B BTR[97]:B BTR[98]:B
*.pininfo BTR[99]:B BTR[100]:B BTR[101]:B BTR[102]:B BTR[103]:B BTR[104]:B
*.pininfo BTR[105]:B BTR[106]:B BTR[107]:B BTR[108]:B BTR[109]:B BTR[110]:B
*.pininfo BTR[111]:B BTR[112]:B BTR[113]:B BTR[114]:B BTR[115]:B BTR[116]:B
*.pininfo BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B BTR[121]:B BTR[122]:B
*.pininfo BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B BTR[127]:B XB[0]:B
*.pininfo XB[1]:B XB[2]:B XB[3]:B XC[0]:B XC[1]:B XC[2]:B XC[3]:B CSH_LD:B
*.pininfo XA[0]:B XA[1]:B XA[2]:B XA[3]:B GRST:B WMO[0]:B WMO[1]:B WMO[2]:B
*.pininfo CSH_RR:B ag_ctrl:B BPUI:B ZRR:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B
*.pininfo QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B
*.pininfo YSEL[0]:B YSEL[1]:B YSEL[2]:B YSEL[3]:B LRST:B VSB[1]:B VSB[2]:B
*.pininfo VSB[3]:B VSB[4]:B WLRST:B XWB[0]:B XWB[1]:B XWB[2]:B XWB[3]:B
*.pininfo RMO[0]:B RMO[1]:B RMO[2]:B VNW:B SPUI:B RWOUT:B CSH_YS[0]:B
*.pininfo CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B EN:B CSH_ENB:B T0EN:B ENB:B
*.pininfo DBL0:B LCLKB:B XARMSBB_R[0]:O XARMSBB_R[1]:O XARMSBB_R[2]:O
*.pininfo XARMSBB_R[3]:O XARLSBA_R[0]:O XARLSBA_R[1]:O XARLSBA_R[2]:O
*.pininfo XARLSBA_R[3]:O XZB[0]:I LXWB_R[0]:O LXWB_R[1]:O LXWB_R[2]:O
*.pininfo LXWB_R[3]:O XARMSBA_R[0]:O XARMSBA_R[1]:O XARMSBA_R[2]:O
*.pininfo XARMSBA_R[3]:O BBMX[32]:B BBMX[33]:B BBMX[34]:B BBMX[35]:B
*.pininfo BBMX[36]:B BBMX[37]:B BBMX[38]:B BBMX[39]:B BBMX[40]:B BBMX[41]:B
*.pininfo BBMX[42]:B BBMX[43]:B BBMX[44]:B BBMX[45]:B BBMX[46]:B BBMX[47]:B
*.pininfo BBMX[48]:B BBMX[49]:B BBMX[50]:B BBMX[51]:B BBMX[52]:B BBMX[53]:B
*.pininfo BBMX[54]:B BBMX[55]:B BBMX[56]:B BBMX[57]:B BBMX[58]:B BBMX[59]:B
*.pininfo BBMX[60]:B BBMX[61]:B BBMX[62]:B BBMX[63]:B BTMX[32]:B BTMX[33]:B
*.pininfo BTMX[34]:B BTMX[35]:B BTMX[36]:B BTMX[37]:B BTMX[38]:B BTMX[39]:B
*.pininfo BTMX[40]:B BTMX[41]:B BTMX[42]:B BTMX[43]:B BTMX[44]:B BTMX[45]:B
*.pininfo BTMX[46]:B BTMX[47]:B BTMX[48]:B BTMX[49]:B BTMX[50]:B BTMX[51]:B
*.pininfo BTMX[52]:B BTMX[53]:B BTMX[54]:B BTMX[55]:B BTMX[56]:B BTMX[57]:B
*.pininfo BTMX[58]:B BTMX[59]:B BTMX[60]:B BTMX[61]:B BTMX[62]:B BTMX[63]:B
*.pininfo GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B GBW[13]:B GBW[14]:B
*.pininfo GBW[15]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B GD[12]:B GD[13]:B
*.pininfo GD[14]:B GD[15]:B GRD0[32]:B GRD0[33]:B GRD0[34]:B GRD0[35]:B
*.pininfo GRD0[36]:B GRD0[37]:B GRD0[38]:B GRD0[39]:B GRD0[40]:B GRD0[41]:B
*.pininfo GRD0[42]:B GRD0[43]:B GRD0[44]:B GRD0[45]:B GRD0[46]:B GRD0[47]:B
*.pininfo GRD0[48]:B GRD0[49]:B GRD0[50]:B GRD0[51]:B GRD0[52]:B GRD0[53]:B
*.pininfo GRD0[54]:B GRD0[55]:B GRD0[56]:B GRD0[57]:B GRD0[58]:B GRD0[59]:B
*.pininfo GRD0[60]:B GRD0[61]:B GRD0[62]:B GRD0[63]:B GRD1[32]:B GRD1[33]:B
*.pininfo GRD1[34]:B GRD1[35]:B GRD1[36]:B GRD1[37]:B GRD1[38]:B GRD1[39]:B
*.pininfo GRD1[40]:B GRD1[41]:B GRD1[42]:B GRD1[43]:B GRD1[44]:B GRD1[45]:B
*.pininfo GRD1[46]:B GRD1[47]:B GRD1[48]:B GRD1[49]:B GRD1[50]:B GRD1[51]:B
*.pininfo GRD1[52]:B GRD1[53]:B GRD1[54]:B GRD1[55]:B GRD1[56]:B GRD1[57]:B
*.pininfo GRD1[58]:B GRD1[59]:B GRD1[60]:B GRD1[61]:B GRD1[62]:B GRD1[63]:B
*.pininfo GRD2[32]:B GRD2[33]:B GRD2[34]:B GRD2[35]:B GRD2[36]:B GRD2[37]:B
*.pininfo GRD2[38]:B GRD2[39]:B GRD2[40]:B GRD2[41]:B GRD2[42]:B GRD2[43]:B
*.pininfo GRD2[44]:B GRD2[45]:B GRD2[46]:B GRD2[47]:B GRD2[48]:B GRD2[49]:B
*.pininfo GRD2[50]:B GRD2[51]:B GRD2[52]:B GRD2[53]:B GRD2[54]:B GRD2[55]:B
*.pininfo GRD2[56]:B GRD2[57]:B GRD2[58]:B GRD2[59]:B GRD2[60]:B GRD2[61]:B
*.pininfo GRD2[62]:B GRD2[63]:B GRD3[32]:B GRD3[33]:B GRD3[34]:B GRD3[35]:B
*.pininfo GRD3[36]:B GRD3[37]:B GRD3[38]:B GRD3[39]:B GRD3[40]:B GRD3[41]:B
*.pininfo GRD3[42]:B GRD3[43]:B GRD3[44]:B GRD3[45]:B GRD3[46]:B GRD3[47]:B
*.pininfo GRD3[48]:B GRD3[49]:B GRD3[50]:B GRD3[51]:B GRD3[52]:B GRD3[53]:B
*.pininfo GRD3[54]:B GRD3[55]:B GRD3[56]:B GRD3[57]:B GRD3[58]:B GRD3[59]:B
*.pininfo GRD3[60]:B GRD3[61]:B GRD3[62]:B GRD3[63]:B LDB[32]:B LDB[33]:B
*.pininfo LDB[34]:B LDB[35]:B LDB[36]:B LDB[37]:B LDB[38]:B LDB[39]:B
*.pininfo LDB[40]:B LDB[41]:B LDB[42]:B LDB[43]:B LDB[44]:B LDB[45]:B
*.pininfo LDB[46]:B LDB[47]:B LDB[48]:B LDB[49]:B LDB[50]:B LDB[51]:B
*.pininfo LDB[52]:B LDB[53]:B LDB[54]:B LDB[55]:B LDB[56]:B LDB[57]:B
*.pininfo LDB[58]:B LDB[59]:B LDB[60]:B LDB[61]:B LDB[62]:B LDB[63]:B
*.pininfo LDT[32]:B LDT[33]:B LDT[34]:B LDT[35]:B LDT[36]:B LDT[37]:B
*.pininfo LDT[38]:B LDT[39]:B LDT[40]:B LDT[41]:B LDT[42]:B LDT[43]:B
*.pininfo LDT[44]:B LDT[45]:B LDT[46]:B LDT[47]:B LDT[48]:B LDT[49]:B
*.pininfo LDT[50]:B LDT[51]:B LDT[52]:B LDT[53]:B LDT[54]:B LDT[55]:B
*.pininfo LDT[56]:B LDT[57]:B LDT[58]:B LDT[59]:B LDT[60]:B LDT[61]:B
*.pininfo LDT[62]:B LDT[63]:B RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B RBBMX[3]:B
*.pininfo RBTMX[0]:B RBTMX[1]:B RBTMX[2]:B RBTMX[3]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B
*.pininfo RGRD3[2]:B RGRD3[3]:B RLDB[0]:B RLDB[1]:B RLDB[2]:B RLDB[3]:B
*.pininfo RLDT[0]:B RLDT[1]:B RLDT[2]:B RLDT[3]:B RGD:B RGBW:B BBR[128]:B
*.pininfo BBR[129]:B BBR[130]:B BBR[131]:B BBR[132]:B BBR[133]:B BBR[134]:B
*.pininfo BBR[135]:B BBR[136]:B BBR[137]:B BBR[138]:B BBR[139]:B BBR[140]:B
*.pininfo BBR[141]:B BBR[142]:B BBR[143]:B BBR[144]:B BBR[145]:B BBR[146]:B
*.pininfo BBR[147]:B BBR[148]:B BBR[149]:B BBR[150]:B BBR[151]:B BBR[152]:B
*.pininfo BBR[153]:B BBR[154]:B BBR[155]:B BBR[156]:B BBR[157]:B BBR[158]:B
*.pininfo BBR[159]:B BBR[160]:B BBR[161]:B BBR[162]:B BBR[163]:B BBR[164]:B
*.pininfo BBR[165]:B BBR[166]:B BBR[167]:B BBR[168]:B BBR[169]:B BBR[170]:B
*.pininfo BBR[171]:B BBR[172]:B BBR[173]:B BBR[174]:B BBR[175]:B BBR[176]:B
*.pininfo BBR[177]:B BBR[178]:B BBR[179]:B BBR[180]:B BBR[181]:B BBR[182]:B
*.pininfo BBR[183]:B BBR[184]:B BBR[185]:B BBR[186]:B BBR[187]:B BBR[188]:B
*.pininfo BBR[189]:B BBR[190]:B BBR[191]:B BBR[192]:B BBR[193]:B BBR[194]:B
*.pininfo BBR[195]:B BBR[196]:B BBR[197]:B BBR[198]:B BBR[199]:B BBR[200]:B
*.pininfo BBR[201]:B BBR[202]:B BBR[203]:B BBR[204]:B BBR[205]:B BBR[206]:B
*.pininfo BBR[207]:B BBR[208]:B BBR[209]:B BBR[210]:B BBR[211]:B BBR[212]:B
*.pininfo BBR[213]:B BBR[214]:B BBR[215]:B BBR[216]:B BBR[217]:B BBR[218]:B
*.pininfo BBR[219]:B BBR[220]:B BBR[221]:B BBR[222]:B BBR[223]:B BBR[224]:B
*.pininfo BBR[225]:B BBR[226]:B BBR[227]:B BBR[228]:B BBR[229]:B BBR[230]:B
*.pininfo BBR[231]:B BBR[232]:B BBR[233]:B BBR[234]:B BBR[235]:B BBR[236]:B
*.pininfo BBR[237]:B BBR[238]:B BBR[239]:B BBR[240]:B BBR[241]:B BBR[242]:B
*.pininfo BBR[243]:B BBR[244]:B BBR[245]:B BBR[246]:B BBR[247]:B BBR[248]:B
*.pininfo BBR[249]:B BBR[250]:B BBR[251]:B BBR[252]:B BBR[253]:B BBR[254]:B
*.pininfo BBR[255]:B BTR[128]:B BTR[129]:B BTR[130]:B BTR[131]:B BTR[132]:B
*.pininfo BTR[133]:B BTR[134]:B BTR[135]:B BTR[136]:B BTR[137]:B BTR[138]:B
*.pininfo BTR[139]:B BTR[140]:B BTR[141]:B BTR[142]:B BTR[143]:B BTR[144]:B
*.pininfo BTR[145]:B BTR[146]:B BTR[147]:B BTR[148]:B BTR[149]:B BTR[150]:B
*.pininfo BTR[151]:B BTR[152]:B BTR[153]:B BTR[154]:B BTR[155]:B BTR[156]:B
*.pininfo BTR[157]:B BTR[158]:B BTR[159]:B BTR[160]:B BTR[161]:B BTR[162]:B
*.pininfo BTR[163]:B BTR[164]:B BTR[165]:B BTR[166]:B BTR[167]:B BTR[168]:B
*.pininfo BTR[169]:B BTR[170]:B BTR[171]:B BTR[172]:B BTR[173]:B BTR[174]:B
*.pininfo BTR[175]:B BTR[176]:B BTR[177]:B BTR[178]:B BTR[179]:B BTR[180]:B
*.pininfo BTR[181]:B BTR[182]:B BTR[183]:B BTR[184]:B BTR[185]:B BTR[186]:B
*.pininfo BTR[187]:B BTR[188]:B BTR[189]:B BTR[190]:B BTR[191]:B BTR[192]:B
*.pininfo BTR[193]:B BTR[194]:B BTR[195]:B BTR[196]:B BTR[197]:B BTR[198]:B
*.pininfo BTR[199]:B BTR[200]:B BTR[201]:B BTR[202]:B BTR[203]:B BTR[204]:B
*.pininfo BTR[205]:B BTR[206]:B BTR[207]:B BTR[208]:B BTR[209]:B BTR[210]:B
*.pininfo BTR[211]:B BTR[212]:B BTR[213]:B BTR[214]:B BTR[215]:B BTR[216]:B
*.pininfo BTR[217]:B BTR[218]:B BTR[219]:B BTR[220]:B BTR[221]:B BTR[222]:B
*.pininfo BTR[223]:B BTR[224]:B BTR[225]:B BTR[226]:B BTR[227]:B BTR[228]:B
*.pininfo BTR[229]:B BTR[230]:B BTR[231]:B BTR[232]:B BTR[233]:B BTR[234]:B
*.pininfo BTR[235]:B BTR[236]:B BTR[237]:B BTR[238]:B BTR[239]:B BTR[240]:B
*.pininfo BTR[241]:B BTR[242]:B BTR[243]:B BTR[244]:B BTR[245]:B BTR[246]:B
*.pininfo BTR[247]:B BTR[248]:B BTR[249]:B BTR[250]:B BTR[251]:B BTR[252]:B
*.pininfo BTR[253]:B BTR[254]:B BTR[255]:B RBB_R[0]:B RBB_R[1]:B RBB_R[2]:B
*.pininfo RBB_R[3]:B RBB_R[4]:B RBB_R[5]:B RBB_R[6]:B RBB_R[7]:B RBB_R[8]:B
*.pininfo RBB_R[9]:B RBB_R[10]:B RBB_R[11]:B RBB_R[12]:B RBB_R[13]:B
*.pininfo RBB_R[14]:B RBB_R[15]:B RBT_R[0]:B RBT_R[1]:B RBT_R[2]:B RBT_R[3]:B
*.pininfo RBT_R[4]:B RBT_R[5]:B RBT_R[6]:B RBT_R[7]:B RBT_R[8]:B RBT_R[9]:B
*.pininfo RBT_R[10]:B RBT_R[11]:B RBT_R[12]:B RBT_R[13]:B RBT_R[14]:B
*.pininfo RBT_R[15]:B
XXspram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_R_0 BBMX[0] BBMX[1] BBMX[2]
+ BBMX[3] BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11]
+ BBMX[12] BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19]
+ BBMX[20] BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27]
+ BBMX[28] BBMX[29] BBMX[30] BBMX[31] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4]
+ BTMX[5] BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9]
+ LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18]
+ LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27]
+ LDB[28] LDB[29] LDB[30] LDB[31] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5]
+ LDT[6] LDT[7] LDT[8] LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15]
+ LDT[16] LDT[17] LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24]
+ LDT[25] LDT[26] LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] VSS VDDA PWR VSSX
+ BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9]
+ BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBR[16] BBR[17] BBR[18]
+ BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27]
+ BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33] BBR[34] BBR[35] BBR[36]
+ BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44] BBR[45]
+ BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52] BBR[53] BBR[54]
+ BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61] BBR[62] BBR[63]
+ BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71] BBR[72]
+ BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96] BBR[97] BBR[98] BBR[99]
+ BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107]
+ BBR[108] BBR[109] BBR[110] BBR[111] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4]
+ BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14]
+ BTR[15] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22] BTR[23]
+ BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31] BTR[32]
+ BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41]
+ BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] BTR[48] BTR[49] BTR[50]
+ BTR[51] BTR[52] BTR[53] BTR[54] BTR[55] BTR[56] BTR[57] BTR[58] BTR[59]
+ BTR[60] BTR[61] BTR[62] BTR[63] BTR[64] BTR[65] BTR[66] BTR[67] BTR[68]
+ BTR[69] BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76] BTR[77]
+ BTR[78] BTR[79] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85] BTR[86]
+ BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94] BTR[95]
+ BTR[96] BTR[97] BTR[98] BTR[99] BTR[100] BTR[101] BTR[102] BTR[103]
+ BTR[104] BTR[105] BTR[106] BTR[107] BTR[108] BTR[109] BTR[110] BTR[111]
+ BTR[112] BTR[113] BTR[114] BTR[115] BTR[116] BTR[117] BTR[118] BTR[119]
+ BTR[120] BTR[121] BTR[122] BTR[123] BTR[124] BTR[125] BTR[126] BTR[127]
+ CSC[0] CSC[1] CSC[2] CSC[3] RBSC[0] RBSC[1] RBSC[2] RBSC[3] SBC[1] SBC[2]
+ SBC[3] SBC[4] WBSC[0] WBSC[1] WBSC[2] WBSC[3] WMHC[0] WMHC[1] WMHC[2] SPUC
+ BPUC AGC VNW SAETC BSTBC SAPRC
+ spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_R m=1
XXspram_4096x16m16b1pm2re1PM2M16B1LIO_LOCCEN_0 XB[0] XB[1] XB[2] XB[3] XC[0]
+ XC[1] XC[2] XC[3] CSH_LD XA[0] XA[1] XA[2] XA[3] GRST WMO[0] WMO[1] WMO[2]
+ CSH_RR ag_ctrl PWR BPUI ZRR QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+ QT[10] QT[11] QT[12] QT[13] YSEL[0] YSEL[1] YSEL[2] YSEL[3] LRST VSB[1]
+ VSB[2] VSB[3] VSB[4] WLRST XWB[0] XWB[1] XWB[2] XWB[3] RMO[0] RMO[1] RMO[2]
+ VNW SPUI RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] EN CSH_ENB T0EN ENB
+ VDDA BPUC SPUC VSS AGC SBC[1] SBC[2] SBC[3] SBC[4] BKSEL CSC[0] CSC[1]
+ CSC[2] CSC[3] BSTBC SAETC SAPRC WMHC[0] WMHC[1] WMHC[2] XZB[0] XARMSBB_R[0]
+ XARMSBB_R[1] XARMSBB_R[2] XARMSBB_R[3] XARLSBA_R[0] XARLSBA_R[1]
+ XARLSBA_R[2] XARLSBA_R[3] LCLKB LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3]
+ XARMSBA_R[0] XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] DBL0 WBSC[0] WBSC[1]
+ WBSC[2] WBSC[3] RBSC[0] RBSC[1] RBSC[2] RBSC[3]
+ spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCCEN m=1
XXspram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_L_0 BBMX[32] BBMX[33] BBMX[34]
+ BBMX[35] BBMX[36] BBMX[37] BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42]
+ BBMX[43] BBMX[44] BBMX[45] BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50]
+ BBMX[51] BBMX[52] BBMX[53] BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58]
+ BBMX[59] BBMX[60] BBMX[61] BBMX[62] BBMX[63] BTMX[32] BTMX[33] BTMX[34]
+ BTMX[35] BTMX[36] BTMX[37] BTMX[38] BTMX[39] BTMX[40] BTMX[41] BTMX[42]
+ BTMX[43] BTMX[44] BTMX[45] BTMX[46] BTMX[47] BTMX[48] BTMX[49] BTMX[50]
+ BTMX[51] BTMX[52] BTMX[53] BTMX[54] BTMX[55] BTMX[56] BTMX[57] BTMX[58]
+ BTMX[59] BTMX[60] BTMX[61] BTMX[62] BTMX[63] GBW[8] GBW[9] GBW[10] GBW[11]
+ GBW[12] GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13]
+ GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37]
+ GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45]
+ GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53]
+ GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61]
+ GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37]
+ GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45]
+ GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53]
+ GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61]
+ GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37]
+ GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45]
+ GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53]
+ GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61]
+ GRD3[62] GRD3[63] LDB[32] LDB[33] LDB[34] LDB[35] LDB[36] LDB[37] LDB[38]
+ LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44] LDB[45] LDB[46] LDB[47]
+ LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53] LDB[54] LDB[55] LDB[56]
+ LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62] LDB[63] LDT[32] LDT[33]
+ LDT[34] LDT[35] LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42]
+ LDT[43] LDT[44] LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51]
+ LDT[52] LDT[53] LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60]
+ LDT[61] LDT[62] LDT[63] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0]
+ RBTMX[1] RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0]
+ RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0]
+ RGRD3[1] RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1]
+ RLDT[2] RLDT[3] VSS VDDA PWR VSSX RGD RGBW BBR[128] BBR[129] BBR[130]
+ BBR[131] BBR[132] BBR[133] BBR[134] BBR[135] BBR[136] BBR[137] BBR[138]
+ BBR[139] BBR[140] BBR[141] BBR[142] BBR[143] BBR[144] BBR[145] BBR[146]
+ BBR[147] BBR[148] BBR[149] BBR[150] BBR[151] BBR[152] BBR[153] BBR[154]
+ BBR[155] BBR[156] BBR[157] BBR[158] BBR[159] BBR[160] BBR[161] BBR[162]
+ BBR[163] BBR[164] BBR[165] BBR[166] BBR[167] BBR[168] BBR[169] BBR[170]
+ BBR[171] BBR[172] BBR[173] BBR[174] BBR[175] BBR[176] BBR[177] BBR[178]
+ BBR[179] BBR[180] BBR[181] BBR[182] BBR[183] BBR[184] BBR[185] BBR[186]
+ BBR[187] BBR[188] BBR[189] BBR[190] BBR[191] BBR[192] BBR[193] BBR[194]
+ BBR[195] BBR[196] BBR[197] BBR[198] BBR[199] BBR[200] BBR[201] BBR[202]
+ BBR[203] BBR[204] BBR[205] BBR[206] BBR[207] BBR[208] BBR[209] BBR[210]
+ BBR[211] BBR[212] BBR[213] BBR[214] BBR[215] BBR[216] BBR[217] BBR[218]
+ BBR[219] BBR[220] BBR[221] BBR[222] BBR[223] BBR[224] BBR[225] BBR[226]
+ BBR[227] BBR[228] BBR[229] BBR[230] BBR[231] BBR[232] BBR[233] BBR[234]
+ BBR[235] BBR[236] BBR[237] BBR[238] BBR[239] BBR[240] BBR[241] BBR[242]
+ BBR[243] BBR[244] BBR[245] BBR[246] BBR[247] BBR[248] BBR[249] BBR[250]
+ BBR[251] BBR[252] BBR[253] BBR[254] BBR[255] BTR[128] BTR[129] BTR[130]
+ BTR[131] BTR[132] BTR[133] BTR[134] BTR[135] BTR[136] BTR[137] BTR[138]
+ BTR[139] BTR[140] BTR[141] BTR[142] BTR[143] BTR[144] BTR[145] BTR[146]
+ BTR[147] BTR[148] BTR[149] BTR[150] BTR[151] BTR[152] BTR[153] BTR[154]
+ BTR[155] BTR[156] BTR[157] BTR[158] BTR[159] BTR[160] BTR[161] BTR[162]
+ BTR[163] BTR[164] BTR[165] BTR[166] BTR[167] BTR[168] BTR[169] BTR[170]
+ BTR[171] BTR[172] BTR[173] BTR[174] BTR[175] BTR[176] BTR[177] BTR[178]
+ BTR[179] BTR[180] BTR[181] BTR[182] BTR[183] BTR[184] BTR[185] BTR[186]
+ BTR[187] BTR[188] BTR[189] BTR[190] BTR[191] BTR[192] BTR[193] BTR[194]
+ BTR[195] BTR[196] BTR[197] BTR[198] BTR[199] BTR[200] BTR[201] BTR[202]
+ BTR[203] BTR[204] BTR[205] BTR[206] BTR[207] BTR[208] BTR[209] BTR[210]
+ BTR[211] BTR[212] BTR[213] BTR[214] BTR[215] BTR[216] BTR[217] BTR[218]
+ BTR[219] BTR[220] BTR[221] BTR[222] BTR[223] BTR[224] BTR[225] BTR[226]
+ BTR[227] BTR[228] BTR[229] BTR[230] BTR[231] BTR[232] BTR[233] BTR[234]
+ BTR[235] BTR[236] BTR[237] BTR[238] BTR[239] BTR[240] BTR[241] BTR[242]
+ BTR[243] BTR[244] BTR[245] BTR[246] BTR[247] BTR[248] BTR[249] BTR[250]
+ BTR[251] BTR[252] BTR[253] BTR[254] BTR[255] RBB_R[0] RBB_R[1] RBB_R[2]
+ RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10]
+ RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1]
+ RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9]
+ RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15] CSC[0] CSC[1]
+ CSC[2] CSC[3] RBSC[0] RBSC[1] RBSC[2] RBSC[3] SBC[1] SBC[2] SBC[3] SBC[4]
+ WBSC[0] WBSC[1] WBSC[2] WBSC[3] WMHC[0] WMHC[1] WMHC[2] SPUC BPUC AGC VNW
+ SAETC BSTBC SAPRC spram_4096x16m16b1pm2re1PM2M16B1LIO_LOCIO_L m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1LIO

.subckt spram_4096x16m16b1pm2re1PM2M16B1 BBMX[0] BBMX[1] BBMX[2] BBMX[3]
+ BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12]
+ BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20]
+ BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28]
+ BBMX[29] BBMX[30] BBMX[31] BBMX[32] BBMX[33] BBMX[34] BBMX[35] BBMX[36]
+ BBMX[37] BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42] BBMX[43] BBMX[44]
+ BBMX[45] BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50] BBMX[51] BBMX[52]
+ BBMX[53] BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58] BBMX[59] BBMX[60]
+ BBMX[61] BBMX[62] BBMX[63] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5]
+ BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] BTMX[32] BTMX[33] BTMX[34] BTMX[35] BTMX[36] BTMX[37]
+ BTMX[38] BTMX[39] BTMX[40] BTMX[41] BTMX[42] BTMX[43] BTMX[44] BTMX[45]
+ BTMX[46] BTMX[47] BTMX[48] BTMX[49] BTMX[50] BTMX[51] BTMX[52] BTMX[53]
+ BTMX[54] BTMX[55] BTMX[56] BTMX[57] BTMX[58] BTMX[59] BTMX[60] BTMX[61]
+ BTMX[62] BTMX[63] CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0] GBW[1]
+ GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GBW[8] GBW[9] GBW[10] GBW[11]
+ GBW[12] GBW[13] GBW[14] GBW[15] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6]
+ GD[7] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD1[32] GRD1[33] GRD1[34] GRD1[35]
+ GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43]
+ GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51]
+ GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59]
+ GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8]
+ LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17]
+ LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26]
+ LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDB[32] LDB[33] LDB[34] LDB[35]
+ LDB[36] LDB[37] LDB[38] LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44]
+ LDB[45] LDB[46] LDB[47] LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53]
+ LDB[54] LDB[55] LDB[56] LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62]
+ LDB[63] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8]
+ LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17]
+ LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26]
+ LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] LDT[32] LDT[33] LDT[34] LDT[35]
+ LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43] LDT[44]
+ LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52] LDT[53]
+ LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61] LDT[62]
+ LDT[63] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+ QT[11] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1] RBTMX[2]
+ RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2]
+ RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2]
+ RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2] RLDT[3]
+ RMO[0] RMO[1] RMO[2] VSB[0] VSB[1] VSB[2] VSB[3] WMO[0] WMO[1] WMO[2] XA[0]
+ XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3] XWB[0]
+ XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] VSS VDDA PWR VSSX
+ CSH_LD GRST CSH_RR ag_ctrl BPUI ZRR LRST WLRST VNW SPUI RWOUT EN CSH_ENB
+ T0EN ENB RGD RGBW BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7]
+ BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBR[16]
+ BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25]
+ BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33] BBR[34]
+ BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42] BBR[43]
+ BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52]
+ BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61]
+ BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70]
+ BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79]
+ BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88]
+ BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96] BBR[97]
+ BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105]
+ BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112] BBR[113]
+ BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121]
+ BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BBR[128] BBR[129]
+ BBR[130] BBR[131] BBR[132] BBR[133] BBR[134] BBR[135] BBR[136] BBR[137]
+ BBR[138] BBR[139] BBR[140] BBR[141] BBR[142] BBR[143] BBR[144] BBR[145]
+ BBR[146] BBR[147] BBR[148] BBR[149] BBR[150] BBR[151] BBR[152] BBR[153]
+ BBR[154] BBR[155] BBR[156] BBR[157] BBR[158] BBR[159] BBR[160] BBR[161]
+ BBR[162] BBR[163] BBR[164] BBR[165] BBR[166] BBR[167] BBR[168] BBR[169]
+ BBR[170] BBR[171] BBR[172] BBR[173] BBR[174] BBR[175] BBR[176] BBR[177]
+ BBR[178] BBR[179] BBR[180] BBR[181] BBR[182] BBR[183] BBR[184] BBR[185]
+ BBR[186] BBR[187] BBR[188] BBR[189] BBR[190] BBR[191] BBR[192] BBR[193]
+ BBR[194] BBR[195] BBR[196] BBR[197] BBR[198] BBR[199] BBR[200] BBR[201]
+ BBR[202] BBR[203] BBR[204] BBR[205] BBR[206] BBR[207] BBR[208] BBR[209]
+ BBR[210] BBR[211] BBR[212] BBR[213] BBR[214] BBR[215] BBR[216] BBR[217]
+ BBR[218] BBR[219] BBR[220] BBR[221] BBR[222] BBR[223] BBR[224] BBR[225]
+ BBR[226] BBR[227] BBR[228] BBR[229] BBR[230] BBR[231] BBR[232] BBR[233]
+ BBR[234] BBR[235] BBR[236] BBR[237] BBR[238] BBR[239] BBR[240] BBR[241]
+ BBR[242] BBR[243] BBR[244] BBR[245] BBR[246] BBR[247] BBR[248] BBR[249]
+ BBR[250] BBR[251] BBR[252] BBR[253] BBR[254] BBR[255] BTR[0] BTR[1] BTR[2]
+ BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12]
+ BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21]
+ BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30]
+ BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39]
+ BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] BTR[48]
+ BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55] BTR[56] BTR[57]
+ BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64] BTR[65] BTR[66]
+ BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75]
+ BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84]
+ BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93]
+ BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100] BTR[101] BTR[102]
+ BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108] BTR[109] BTR[110]
+ BTR[111] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116] BTR[117] BTR[118]
+ BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124] BTR[125] BTR[126]
+ BTR[127] BTR[128] BTR[129] BTR[130] BTR[131] BTR[132] BTR[133] BTR[134]
+ BTR[135] BTR[136] BTR[137] BTR[138] BTR[139] BTR[140] BTR[141] BTR[142]
+ BTR[143] BTR[144] BTR[145] BTR[146] BTR[147] BTR[148] BTR[149] BTR[150]
+ BTR[151] BTR[152] BTR[153] BTR[154] BTR[155] BTR[156] BTR[157] BTR[158]
+ BTR[159] BTR[160] BTR[161] BTR[162] BTR[163] BTR[164] BTR[165] BTR[166]
+ BTR[167] BTR[168] BTR[169] BTR[170] BTR[171] BTR[172] BTR[173] BTR[174]
+ BTR[175] BTR[176] BTR[177] BTR[178] BTR[179] BTR[180] BTR[181] BTR[182]
+ BTR[183] BTR[184] BTR[185] BTR[186] BTR[187] BTR[188] BTR[189] BTR[190]
+ BTR[191] BTR[192] BTR[193] BTR[194] BTR[195] BTR[196] BTR[197] BTR[198]
+ BTR[199] BTR[200] BTR[201] BTR[202] BTR[203] BTR[204] BTR[205] BTR[206]
+ BTR[207] BTR[208] BTR[209] BTR[210] BTR[211] BTR[212] BTR[213] BTR[214]
+ BTR[215] BTR[216] BTR[217] BTR[218] BTR[219] BTR[220] BTR[221] BTR[222]
+ BTR[223] BTR[224] BTR[225] BTR[226] BTR[227] BTR[228] BTR[229] BTR[230]
+ BTR[231] BTR[232] BTR[233] BTR[234] BTR[235] BTR[236] BTR[237] BTR[238]
+ BTR[239] BTR[240] BTR[241] BTR[242] BTR[243] BTR[244] BTR[245] BTR[246]
+ BTR[247] BTR[248] BTR[249] BTR[250] BTR[251] BTR[252] BTR[253] BTR[254]
+ BTR[255] LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3] RBB_R[0] RBB_R[1] RBB_R[2]
+ RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10]
+ RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1]
+ RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9]
+ RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15] XARLSBA_R[0]
+ XARLSBA_R[1] XARLSBA_R[2] XARLSBA_R[3] XARMSBA_R[0] XARMSBA_R[1]
+ XARMSBA_R[2] XARMSBA_R[3] XARMSBB_R[0] XARMSBB_R[1] XARMSBB_R[2]
+ XARMSBB_R[3] XZB[0] DBL0 LCLKB
*.pininfo BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B BBMX[16]:B BBMX[17]:B
*.pininfo BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B
*.pininfo BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B BBMX[28]:B BBMX[29]:B
*.pininfo BBMX[30]:B BBMX[31]:B BBMX[32]:B BBMX[33]:B BBMX[34]:B BBMX[35]:B
*.pininfo BBMX[36]:B BBMX[37]:B BBMX[38]:B BBMX[39]:B BBMX[40]:B BBMX[41]:B
*.pininfo BBMX[42]:B BBMX[43]:B BBMX[44]:B BBMX[45]:B BBMX[46]:B BBMX[47]:B
*.pininfo BBMX[48]:B BBMX[49]:B BBMX[50]:B BBMX[51]:B BBMX[52]:B BBMX[53]:B
*.pininfo BBMX[54]:B BBMX[55]:B BBMX[56]:B BBMX[57]:B BBMX[58]:B BBMX[59]:B
*.pininfo BBMX[60]:B BBMX[61]:B BBMX[62]:B BBMX[63]:B BTMX[0]:B BTMX[1]:B
*.pininfo BTMX[2]:B BTMX[3]:B BTMX[4]:B BTMX[5]:B BTMX[6]:B BTMX[7]:B
*.pininfo BTMX[8]:B BTMX[9]:B BTMX[10]:B BTMX[11]:B BTMX[12]:B BTMX[13]:B
*.pininfo BTMX[14]:B BTMX[15]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B BTMX[19]:B
*.pininfo BTMX[20]:B BTMX[21]:B BTMX[22]:B BTMX[23]:B BTMX[24]:B BTMX[25]:B
*.pininfo BTMX[26]:B BTMX[27]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B BTMX[31]:B
*.pininfo BTMX[32]:B BTMX[33]:B BTMX[34]:B BTMX[35]:B BTMX[36]:B BTMX[37]:B
*.pininfo BTMX[38]:B BTMX[39]:B BTMX[40]:B BTMX[41]:B BTMX[42]:B BTMX[43]:B
*.pininfo BTMX[44]:B BTMX[45]:B BTMX[46]:B BTMX[47]:B BTMX[48]:B BTMX[49]:B
*.pininfo BTMX[50]:B BTMX[51]:B BTMX[52]:B BTMX[53]:B BTMX[54]:B BTMX[55]:B
*.pininfo BTMX[56]:B BTMX[57]:B BTMX[58]:B BTMX[59]:B BTMX[60]:B BTMX[61]:B
*.pininfo BTMX[62]:B BTMX[63]:B CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B
*.pininfo CSH_YS[3]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B
*.pininfo GBW[6]:B GBW[7]:B GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B
*.pininfo GBW[13]:B GBW[14]:B GBW[15]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B
*.pininfo GD[12]:B GD[13]:B GD[14]:B GD[15]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD0[32]:B
*.pininfo GRD0[33]:B GRD0[34]:B GRD0[35]:B GRD0[36]:B GRD0[37]:B GRD0[38]:B
*.pininfo GRD0[39]:B GRD0[40]:B GRD0[41]:B GRD0[42]:B GRD0[43]:B GRD0[44]:B
*.pininfo GRD0[45]:B GRD0[46]:B GRD0[47]:B GRD0[48]:B GRD0[49]:B GRD0[50]:B
*.pininfo GRD0[51]:B GRD0[52]:B GRD0[53]:B GRD0[54]:B GRD0[55]:B GRD0[56]:B
*.pininfo GRD0[57]:B GRD0[58]:B GRD0[59]:B GRD0[60]:B GRD0[61]:B GRD0[62]:B
*.pininfo GRD0[63]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD1[32]:B GRD1[33]:B GRD1[34]:B
*.pininfo GRD1[35]:B GRD1[36]:B GRD1[37]:B GRD1[38]:B GRD1[39]:B GRD1[40]:B
*.pininfo GRD1[41]:B GRD1[42]:B GRD1[43]:B GRD1[44]:B GRD1[45]:B GRD1[46]:B
*.pininfo GRD1[47]:B GRD1[48]:B GRD1[49]:B GRD1[50]:B GRD1[51]:B GRD1[52]:B
*.pininfo GRD1[53]:B GRD1[54]:B GRD1[55]:B GRD1[56]:B GRD1[57]:B GRD1[58]:B
*.pininfo GRD1[59]:B GRD1[60]:B GRD1[61]:B GRD1[62]:B GRD1[63]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B
*.pininfo GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B
*.pininfo GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B
*.pininfo GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B
*.pininfo GRD2[31]:B GRD2[32]:B GRD2[33]:B GRD2[34]:B GRD2[35]:B GRD2[36]:B
*.pininfo GRD2[37]:B GRD2[38]:B GRD2[39]:B GRD2[40]:B GRD2[41]:B GRD2[42]:B
*.pininfo GRD2[43]:B GRD2[44]:B GRD2[45]:B GRD2[46]:B GRD2[47]:B GRD2[48]:B
*.pininfo GRD2[49]:B GRD2[50]:B GRD2[51]:B GRD2[52]:B GRD2[53]:B GRD2[54]:B
*.pininfo GRD2[55]:B GRD2[56]:B GRD2[57]:B GRD2[58]:B GRD2[59]:B GRD2[60]:B
*.pininfo GRD2[61]:B GRD2[62]:B GRD2[63]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B GRD3[32]:B
*.pininfo GRD3[33]:B GRD3[34]:B GRD3[35]:B GRD3[36]:B GRD3[37]:B GRD3[38]:B
*.pininfo GRD3[39]:B GRD3[40]:B GRD3[41]:B GRD3[42]:B GRD3[43]:B GRD3[44]:B
*.pininfo GRD3[45]:B GRD3[46]:B GRD3[47]:B GRD3[48]:B GRD3[49]:B GRD3[50]:B
*.pininfo GRD3[51]:B GRD3[52]:B GRD3[53]:B GRD3[54]:B GRD3[55]:B GRD3[56]:B
*.pininfo GRD3[57]:B GRD3[58]:B GRD3[59]:B GRD3[60]:B GRD3[61]:B GRD3[62]:B
*.pininfo GRD3[63]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDB[4]:B LDB[5]:B
*.pininfo LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B LDB[12]:B
*.pininfo LDB[13]:B LDB[14]:B LDB[15]:B LDB[16]:B LDB[17]:B LDB[18]:B
*.pininfo LDB[19]:B LDB[20]:B LDB[21]:B LDB[22]:B LDB[23]:B LDB[24]:B
*.pininfo LDB[25]:B LDB[26]:B LDB[27]:B LDB[28]:B LDB[29]:B LDB[30]:B
*.pininfo LDB[31]:B LDB[32]:B LDB[33]:B LDB[34]:B LDB[35]:B LDB[36]:B
*.pininfo LDB[37]:B LDB[38]:B LDB[39]:B LDB[40]:B LDB[41]:B LDB[42]:B
*.pininfo LDB[43]:B LDB[44]:B LDB[45]:B LDB[46]:B LDB[47]:B LDB[48]:B
*.pininfo LDB[49]:B LDB[50]:B LDB[51]:B LDB[52]:B LDB[53]:B LDB[54]:B
*.pininfo LDB[55]:B LDB[56]:B LDB[57]:B LDB[58]:B LDB[59]:B LDB[60]:B
*.pininfo LDB[61]:B LDB[62]:B LDB[63]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B
*.pininfo LDT[4]:B LDT[5]:B LDT[6]:B LDT[7]:B LDT[8]:B LDT[9]:B LDT[10]:B
*.pininfo LDT[11]:B LDT[12]:B LDT[13]:B LDT[14]:B LDT[15]:B LDT[16]:B
*.pininfo LDT[17]:B LDT[18]:B LDT[19]:B LDT[20]:B LDT[21]:B LDT[22]:B
*.pininfo LDT[23]:B LDT[24]:B LDT[25]:B LDT[26]:B LDT[27]:B LDT[28]:B
*.pininfo LDT[29]:B LDT[30]:B LDT[31]:B LDT[32]:B LDT[33]:B LDT[34]:B
*.pininfo LDT[35]:B LDT[36]:B LDT[37]:B LDT[38]:B LDT[39]:B LDT[40]:B
*.pininfo LDT[41]:B LDT[42]:B LDT[43]:B LDT[44]:B LDT[45]:B LDT[46]:B
*.pininfo LDT[47]:B LDT[48]:B LDT[49]:B LDT[50]:B LDT[51]:B LDT[52]:B
*.pininfo LDT[53]:B LDT[54]:B LDT[55]:B LDT[56]:B LDT[57]:B LDT[58]:B
*.pininfo LDT[59]:B LDT[60]:B LDT[61]:B LDT[62]:B LDT[63]:B QT[0]:B QT[1]:B
*.pininfo QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B
*.pininfo QT[10]:B QT[11]:B RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B RBBMX[3]:B
*.pininfo RBTMX[0]:B RBTMX[1]:B RBTMX[2]:B RBTMX[3]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B
*.pininfo RGRD3[2]:B RGRD3[3]:B RLDB[0]:B RLDB[1]:B RLDB[2]:B RLDB[3]:B
*.pininfo RLDT[0]:B RLDT[1]:B RLDT[2]:B RLDT[3]:B RMO[0]:B RMO[1]:B RMO[2]:B
*.pininfo VSB[0]:B VSB[1]:B VSB[2]:B VSB[3]:B WMO[0]:B WMO[1]:B WMO[2]:B
*.pininfo XA[0]:B XA[1]:B XA[2]:B XA[3]:B XB[0]:B XB[1]:B XB[2]:B XB[3]:B
*.pininfo XC[0]:B XC[1]:B XC[2]:B XC[3]:B XWB[0]:B XWB[1]:B XWB[2]:B XWB[3]:B
*.pininfo YSEL[0]:B YSEL[1]:B YSEL[2]:B YSEL[3]:B VSS:B VDDA:B PWR:B VSSX:B
*.pininfo CSH_LD:B GRST:B CSH_RR:B ag_ctrl:B BPUI:B ZRR:B LRST:B WLRST:B
*.pininfo VNW:B SPUI:B RWOUT:B EN:B CSH_ENB:B T0EN:B ENB:B RGD:B RGBW:B
*.pininfo BBR[0]:B BBR[1]:B BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B
*.pininfo BBR[7]:B BBR[8]:B BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B
*.pininfo BBR[14]:B BBR[15]:B BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B
*.pininfo BBR[20]:B BBR[21]:B BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B
*.pininfo BBR[26]:B BBR[27]:B BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B
*.pininfo BBR[32]:B BBR[33]:B BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B
*.pininfo BBR[38]:B BBR[39]:B BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B
*.pininfo BBR[44]:B BBR[45]:B BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B
*.pininfo BBR[50]:B BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B
*.pininfo BBR[56]:B BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B
*.pininfo BBR[62]:B BBR[63]:B BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B
*.pininfo BBR[68]:B BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B
*.pininfo BBR[74]:B BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B
*.pininfo BBR[80]:B BBR[81]:B BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B
*.pininfo BBR[86]:B BBR[87]:B BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B
*.pininfo BBR[92]:B BBR[93]:B BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B
*.pininfo BBR[98]:B BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B
*.pininfo BBR[104]:B BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B
*.pininfo BBR[110]:B BBR[111]:B BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B
*.pininfo BBR[116]:B BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B
*.pininfo BBR[122]:B BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B
*.pininfo BBR[128]:B BBR[129]:B BBR[130]:B BBR[131]:B BBR[132]:B BBR[133]:B
*.pininfo BBR[134]:B BBR[135]:B BBR[136]:B BBR[137]:B BBR[138]:B BBR[139]:B
*.pininfo BBR[140]:B BBR[141]:B BBR[142]:B BBR[143]:B BBR[144]:B BBR[145]:B
*.pininfo BBR[146]:B BBR[147]:B BBR[148]:B BBR[149]:B BBR[150]:B BBR[151]:B
*.pininfo BBR[152]:B BBR[153]:B BBR[154]:B BBR[155]:B BBR[156]:B BBR[157]:B
*.pininfo BBR[158]:B BBR[159]:B BBR[160]:B BBR[161]:B BBR[162]:B BBR[163]:B
*.pininfo BBR[164]:B BBR[165]:B BBR[166]:B BBR[167]:B BBR[168]:B BBR[169]:B
*.pininfo BBR[170]:B BBR[171]:B BBR[172]:B BBR[173]:B BBR[174]:B BBR[175]:B
*.pininfo BBR[176]:B BBR[177]:B BBR[178]:B BBR[179]:B BBR[180]:B BBR[181]:B
*.pininfo BBR[182]:B BBR[183]:B BBR[184]:B BBR[185]:B BBR[186]:B BBR[187]:B
*.pininfo BBR[188]:B BBR[189]:B BBR[190]:B BBR[191]:B BBR[192]:B BBR[193]:B
*.pininfo BBR[194]:B BBR[195]:B BBR[196]:B BBR[197]:B BBR[198]:B BBR[199]:B
*.pininfo BBR[200]:B BBR[201]:B BBR[202]:B BBR[203]:B BBR[204]:B BBR[205]:B
*.pininfo BBR[206]:B BBR[207]:B BBR[208]:B BBR[209]:B BBR[210]:B BBR[211]:B
*.pininfo BBR[212]:B BBR[213]:B BBR[214]:B BBR[215]:B BBR[216]:B BBR[217]:B
*.pininfo BBR[218]:B BBR[219]:B BBR[220]:B BBR[221]:B BBR[222]:B BBR[223]:B
*.pininfo BBR[224]:B BBR[225]:B BBR[226]:B BBR[227]:B BBR[228]:B BBR[229]:B
*.pininfo BBR[230]:B BBR[231]:B BBR[232]:B BBR[233]:B BBR[234]:B BBR[235]:B
*.pininfo BBR[236]:B BBR[237]:B BBR[238]:B BBR[239]:B BBR[240]:B BBR[241]:B
*.pininfo BBR[242]:B BBR[243]:B BBR[244]:B BBR[245]:B BBR[246]:B BBR[247]:B
*.pininfo BBR[248]:B BBR[249]:B BBR[250]:B BBR[251]:B BBR[252]:B BBR[253]:B
*.pininfo BBR[254]:B BBR[255]:B BTR[0]:B BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B
*.pininfo BTR[5]:B BTR[6]:B BTR[7]:B BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B
*.pininfo BTR[12]:B BTR[13]:B BTR[14]:B BTR[15]:B BTR[16]:B BTR[17]:B
*.pininfo BTR[18]:B BTR[19]:B BTR[20]:B BTR[21]:B BTR[22]:B BTR[23]:B
*.pininfo BTR[24]:B BTR[25]:B BTR[26]:B BTR[27]:B BTR[28]:B BTR[29]:B
*.pininfo BTR[30]:B BTR[31]:B BTR[32]:B BTR[33]:B BTR[34]:B BTR[35]:B
*.pininfo BTR[36]:B BTR[37]:B BTR[38]:B BTR[39]:B BTR[40]:B BTR[41]:B
*.pininfo BTR[42]:B BTR[43]:B BTR[44]:B BTR[45]:B BTR[46]:B BTR[47]:B
*.pininfo BTR[48]:B BTR[49]:B BTR[50]:B BTR[51]:B BTR[52]:B BTR[53]:B
*.pininfo BTR[54]:B BTR[55]:B BTR[56]:B BTR[57]:B BTR[58]:B BTR[59]:B
*.pininfo BTR[60]:B BTR[61]:B BTR[62]:B BTR[63]:B BTR[64]:B BTR[65]:B
*.pininfo BTR[66]:B BTR[67]:B BTR[68]:B BTR[69]:B BTR[70]:B BTR[71]:B
*.pininfo BTR[72]:B BTR[73]:B BTR[74]:B BTR[75]:B BTR[76]:B BTR[77]:B
*.pininfo BTR[78]:B BTR[79]:B BTR[80]:B BTR[81]:B BTR[82]:B BTR[83]:B
*.pininfo BTR[84]:B BTR[85]:B BTR[86]:B BTR[87]:B BTR[88]:B BTR[89]:B
*.pininfo BTR[90]:B BTR[91]:B BTR[92]:B BTR[93]:B BTR[94]:B BTR[95]:B
*.pininfo BTR[96]:B BTR[97]:B BTR[98]:B BTR[99]:B BTR[100]:B BTR[101]:B
*.pininfo BTR[102]:B BTR[103]:B BTR[104]:B BTR[105]:B BTR[106]:B BTR[107]:B
*.pininfo BTR[108]:B BTR[109]:B BTR[110]:B BTR[111]:B BTR[112]:B BTR[113]:B
*.pininfo BTR[114]:B BTR[115]:B BTR[116]:B BTR[117]:B BTR[118]:B BTR[119]:B
*.pininfo BTR[120]:B BTR[121]:B BTR[122]:B BTR[123]:B BTR[124]:B BTR[125]:B
*.pininfo BTR[126]:B BTR[127]:B BTR[128]:B BTR[129]:B BTR[130]:B BTR[131]:B
*.pininfo BTR[132]:B BTR[133]:B BTR[134]:B BTR[135]:B BTR[136]:B BTR[137]:B
*.pininfo BTR[138]:B BTR[139]:B BTR[140]:B BTR[141]:B BTR[142]:B BTR[143]:B
*.pininfo BTR[144]:B BTR[145]:B BTR[146]:B BTR[147]:B BTR[148]:B BTR[149]:B
*.pininfo BTR[150]:B BTR[151]:B BTR[152]:B BTR[153]:B BTR[154]:B BTR[155]:B
*.pininfo BTR[156]:B BTR[157]:B BTR[158]:B BTR[159]:B BTR[160]:B BTR[161]:B
*.pininfo BTR[162]:B BTR[163]:B BTR[164]:B BTR[165]:B BTR[166]:B BTR[167]:B
*.pininfo BTR[168]:B BTR[169]:B BTR[170]:B BTR[171]:B BTR[172]:B BTR[173]:B
*.pininfo BTR[174]:B BTR[175]:B BTR[176]:B BTR[177]:B BTR[178]:B BTR[179]:B
*.pininfo BTR[180]:B BTR[181]:B BTR[182]:B BTR[183]:B BTR[184]:B BTR[185]:B
*.pininfo BTR[186]:B BTR[187]:B BTR[188]:B BTR[189]:B BTR[190]:B BTR[191]:B
*.pininfo BTR[192]:B BTR[193]:B BTR[194]:B BTR[195]:B BTR[196]:B BTR[197]:B
*.pininfo BTR[198]:B BTR[199]:B BTR[200]:B BTR[201]:B BTR[202]:B BTR[203]:B
*.pininfo BTR[204]:B BTR[205]:B BTR[206]:B BTR[207]:B BTR[208]:B BTR[209]:B
*.pininfo BTR[210]:B BTR[211]:B BTR[212]:B BTR[213]:B BTR[214]:B BTR[215]:B
*.pininfo BTR[216]:B BTR[217]:B BTR[218]:B BTR[219]:B BTR[220]:B BTR[221]:B
*.pininfo BTR[222]:B BTR[223]:B BTR[224]:B BTR[225]:B BTR[226]:B BTR[227]:B
*.pininfo BTR[228]:B BTR[229]:B BTR[230]:B BTR[231]:B BTR[232]:B BTR[233]:B
*.pininfo BTR[234]:B BTR[235]:B BTR[236]:B BTR[237]:B BTR[238]:B BTR[239]:B
*.pininfo BTR[240]:B BTR[241]:B BTR[242]:B BTR[243]:B BTR[244]:B BTR[245]:B
*.pininfo BTR[246]:B BTR[247]:B BTR[248]:B BTR[249]:B BTR[250]:B BTR[251]:B
*.pininfo BTR[252]:B BTR[253]:B BTR[254]:B BTR[255]:B LXWB_R[0]:O LXWB_R[1]:O
*.pininfo LXWB_R[2]:O LXWB_R[3]:O RBB_R[0]:B RBB_R[1]:B RBB_R[2]:B RBB_R[3]:B
*.pininfo RBB_R[4]:B RBB_R[5]:B RBB_R[6]:B RBB_R[7]:B RBB_R[8]:B RBB_R[9]:B
*.pininfo RBB_R[10]:B RBB_R[11]:B RBB_R[12]:B RBB_R[13]:B RBB_R[14]:B
*.pininfo RBB_R[15]:B RBT_R[0]:B RBT_R[1]:B RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B
*.pininfo RBT_R[5]:B RBT_R[6]:B RBT_R[7]:B RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B
*.pininfo RBT_R[11]:B RBT_R[12]:B RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B
*.pininfo XARLSBA_R[0]:O XARLSBA_R[1]:O XARLSBA_R[2]:O XARLSBA_R[3]:O
*.pininfo XARMSBA_R[0]:O XARMSBA_R[1]:O XARMSBA_R[2]:O XARMSBA_R[3]:O
*.pininfo XARMSBB_R[0]:O XARMSBB_R[1]:O XARMSBB_R[2]:O XARMSBB_R[3]:O
*.pininfo XZB[0]:I DBL0:B LCLKB:B
XXspram_4096x16m16b1pm2re1PM2M16B1LIO_0 BBMX[0] BBMX[1] BBMX[2] BBMX[3]
+ BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12]
+ BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20]
+ BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28]
+ BBMX[29] BBMX[30] BBMX[31] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5]
+ BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11]
+ GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19]
+ GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27]
+ GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4]
+ GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9]
+ LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18]
+ LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27]
+ LDB[28] LDB[29] LDB[30] LDB[31] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5]
+ LDT[6] LDT[7] LDT[8] LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15]
+ LDT[16] LDT[17] LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24]
+ LDT[25] LDT[26] LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] VSS VDDA PWR VSSX
+ BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9]
+ BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBR[16] BBR[17] BBR[18]
+ BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27]
+ BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33] BBR[34] BBR[35] BBR[36]
+ BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44] BBR[45]
+ BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52] BBR[53] BBR[54]
+ BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61] BBR[62] BBR[63]
+ BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71] BBR[72]
+ BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96] BBR[97] BBR[98] BBR[99]
+ BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107]
+ BBR[108] BBR[109] BBR[110] BBR[111] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4]
+ BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14]
+ BTR[15] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22] BTR[23]
+ BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31] BTR[32]
+ BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41]
+ BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] BTR[48] BTR[49] BTR[50]
+ BTR[51] BTR[52] BTR[53] BTR[54] BTR[55] BTR[56] BTR[57] BTR[58] BTR[59]
+ BTR[60] BTR[61] BTR[62] BTR[63] BTR[64] BTR[65] BTR[66] BTR[67] BTR[68]
+ BTR[69] BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76] BTR[77]
+ BTR[78] BTR[79] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85] BTR[86]
+ BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94] BTR[95]
+ BTR[96] BTR[97] BTR[98] BTR[99] BTR[100] BTR[101] BTR[102] BTR[103]
+ BTR[104] BTR[105] BTR[106] BTR[107] BTR[108] BTR[109] BTR[110] BTR[111]
+ BTR[112] BTR[113] BTR[114] BTR[115] BTR[116] BTR[117] BTR[118] BTR[119]
+ BTR[120] BTR[121] BTR[122] BTR[123] BTR[124] BTR[125] BTR[126] BTR[127]
+ XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3] CSH_LD XA[0] XA[1] XA[2]
+ XA[3] GRST WMO[0] WMO[1] WMO[2] CSH_RR ag_ctrl BPUI ZRR QT[0] QT[1] QT[2]
+ QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] YSEL[0] YSEL[1]
+ YSEL[2] YSEL[3] LRST VSB[0] VSB[1] VSB[2] VSB[3] WLRST XWB[0] XWB[1] XWB[2]
+ XWB[3] RMO[0] RMO[1] RMO[2] VNW SPUI RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] EN CSH_ENB T0EN ENB DBL0 LCLKB XARMSBB_R[0] XARMSBB_R[1]
+ XARMSBB_R[2] XARMSBB_R[3] XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2]
+ XARLSBA_R[3] XZB[0] LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3] XARMSBA_R[0]
+ XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] BBMX[32] BBMX[33] BBMX[34] BBMX[35]
+ BBMX[36] BBMX[37] BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42] BBMX[43]
+ BBMX[44] BBMX[45] BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50] BBMX[51]
+ BBMX[52] BBMX[53] BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58] BBMX[59]
+ BBMX[60] BBMX[61] BBMX[62] BBMX[63] BTMX[32] BTMX[33] BTMX[34] BTMX[35]
+ BTMX[36] BTMX[37] BTMX[38] BTMX[39] BTMX[40] BTMX[41] BTMX[42] BTMX[43]
+ BTMX[44] BTMX[45] BTMX[46] BTMX[47] BTMX[48] BTMX[49] BTMX[50] BTMX[51]
+ BTMX[52] BTMX[53] BTMX[54] BTMX[55] BTMX[56] BTMX[57] BTMX[58] BTMX[59]
+ BTMX[60] BTMX[61] BTMX[62] BTMX[63] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12]
+ GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14]
+ GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37] GRD0[38]
+ GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45] GRD0[46]
+ GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53] GRD0[54]
+ GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61] GRD0[62]
+ GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38]
+ GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46]
+ GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54]
+ GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62]
+ GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38]
+ GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46]
+ GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54]
+ GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62]
+ GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] LDB[32] LDB[33] LDB[34] LDB[35] LDB[36] LDB[37] LDB[38] LDB[39]
+ LDB[40] LDB[41] LDB[42] LDB[43] LDB[44] LDB[45] LDB[46] LDB[47] LDB[48]
+ LDB[49] LDB[50] LDB[51] LDB[52] LDB[53] LDB[54] LDB[55] LDB[56] LDB[57]
+ LDB[58] LDB[59] LDB[60] LDB[61] LDB[62] LDB[63] LDT[32] LDT[33] LDT[34]
+ LDT[35] LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43]
+ LDT[44] LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52]
+ LDT[53] LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61]
+ LDT[62] LDT[63] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1]
+ RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2]
+ RLDT[3] RGD RGBW BBR[128] BBR[129] BBR[130] BBR[131] BBR[132] BBR[133]
+ BBR[134] BBR[135] BBR[136] BBR[137] BBR[138] BBR[139] BBR[140] BBR[141]
+ BBR[142] BBR[143] BBR[144] BBR[145] BBR[146] BBR[147] BBR[148] BBR[149]
+ BBR[150] BBR[151] BBR[152] BBR[153] BBR[154] BBR[155] BBR[156] BBR[157]
+ BBR[158] BBR[159] BBR[160] BBR[161] BBR[162] BBR[163] BBR[164] BBR[165]
+ BBR[166] BBR[167] BBR[168] BBR[169] BBR[170] BBR[171] BBR[172] BBR[173]
+ BBR[174] BBR[175] BBR[176] BBR[177] BBR[178] BBR[179] BBR[180] BBR[181]
+ BBR[182] BBR[183] BBR[184] BBR[185] BBR[186] BBR[187] BBR[188] BBR[189]
+ BBR[190] BBR[191] BBR[192] BBR[193] BBR[194] BBR[195] BBR[196] BBR[197]
+ BBR[198] BBR[199] BBR[200] BBR[201] BBR[202] BBR[203] BBR[204] BBR[205]
+ BBR[206] BBR[207] BBR[208] BBR[209] BBR[210] BBR[211] BBR[212] BBR[213]
+ BBR[214] BBR[215] BBR[216] BBR[217] BBR[218] BBR[219] BBR[220] BBR[221]
+ BBR[222] BBR[223] BBR[224] BBR[225] BBR[226] BBR[227] BBR[228] BBR[229]
+ BBR[230] BBR[231] BBR[232] BBR[233] BBR[234] BBR[235] BBR[236] BBR[237]
+ BBR[238] BBR[239] BBR[240] BBR[241] BBR[242] BBR[243] BBR[244] BBR[245]
+ BBR[246] BBR[247] BBR[248] BBR[249] BBR[250] BBR[251] BBR[252] BBR[253]
+ BBR[254] BBR[255] BTR[128] BTR[129] BTR[130] BTR[131] BTR[132] BTR[133]
+ BTR[134] BTR[135] BTR[136] BTR[137] BTR[138] BTR[139] BTR[140] BTR[141]
+ BTR[142] BTR[143] BTR[144] BTR[145] BTR[146] BTR[147] BTR[148] BTR[149]
+ BTR[150] BTR[151] BTR[152] BTR[153] BTR[154] BTR[155] BTR[156] BTR[157]
+ BTR[158] BTR[159] BTR[160] BTR[161] BTR[162] BTR[163] BTR[164] BTR[165]
+ BTR[166] BTR[167] BTR[168] BTR[169] BTR[170] BTR[171] BTR[172] BTR[173]
+ BTR[174] BTR[175] BTR[176] BTR[177] BTR[178] BTR[179] BTR[180] BTR[181]
+ BTR[182] BTR[183] BTR[184] BTR[185] BTR[186] BTR[187] BTR[188] BTR[189]
+ BTR[190] BTR[191] BTR[192] BTR[193] BTR[194] BTR[195] BTR[196] BTR[197]
+ BTR[198] BTR[199] BTR[200] BTR[201] BTR[202] BTR[203] BTR[204] BTR[205]
+ BTR[206] BTR[207] BTR[208] BTR[209] BTR[210] BTR[211] BTR[212] BTR[213]
+ BTR[214] BTR[215] BTR[216] BTR[217] BTR[218] BTR[219] BTR[220] BTR[221]
+ BTR[222] BTR[223] BTR[224] BTR[225] BTR[226] BTR[227] BTR[228] BTR[229]
+ BTR[230] BTR[231] BTR[232] BTR[233] BTR[234] BTR[235] BTR[236] BTR[237]
+ BTR[238] BTR[239] BTR[240] BTR[241] BTR[242] BTR[243] BTR[244] BTR[245]
+ BTR[246] BTR[247] BTR[248] BTR[249] BTR[250] BTR[251] BTR[252] BTR[253]
+ BTR[254] BTR[255] RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5]
+ RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13]
+ RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5]
+ RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13]
+ RBT_R[14] RBT_R[15] spram_4096x16m16b1pm2re1PM2M16B1LIO m=1
.ends spram_4096x16m16b1pm2re1PM2M16B1

.subckt spram_4096x16m16b1pm2re1BNK1_SLIO BBMX[0] BBMX[1] BBMX[2] BBMX[3]
+ BBMX[4] BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12]
+ BBMX[13] BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20]
+ BBMX[21] BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28]
+ BBMX[29] BBMX[30] BBMX[31] BBMX[32] BBMX[33] BBMX[34] BBMX[35] BBMX[36]
+ BBMX[37] BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42] BBMX[43] BBMX[44]
+ BBMX[45] BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50] BBMX[51] BBMX[52]
+ BBMX[53] BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58] BBMX[59] BBMX[60]
+ BBMX[61] BBMX[62] BBMX[63] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5]
+ BTMX[6] BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13]
+ BTMX[14] BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21]
+ BTMX[22] BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29]
+ BTMX[30] BTMX[31] BTMX[32] BTMX[33] BTMX[34] BTMX[35] BTMX[36] BTMX[37]
+ BTMX[38] BTMX[39] BTMX[40] BTMX[41] BTMX[42] BTMX[43] BTMX[44] BTMX[45]
+ BTMX[46] BTMX[47] BTMX[48] BTMX[49] BTMX[50] BTMX[51] BTMX[52] BTMX[53]
+ BTMX[54] BTMX[55] BTMX[56] BTMX[57] BTMX[58] BTMX[59] BTMX[60] BTMX[61]
+ BTMX[62] BTMX[63] CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0] GBW[1]
+ GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GBW[8] GBW[9] GBW[10] GBW[11]
+ GBW[12] GBW[13] GBW[14] GBW[15] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6]
+ GD[7] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD1[32] GRD1[33] GRD1[34] GRD1[35]
+ GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43]
+ GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51]
+ GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59]
+ GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8]
+ LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17]
+ LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26]
+ LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDB[32] LDB[33] LDB[34] LDB[35]
+ LDB[36] LDB[37] LDB[38] LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44]
+ LDB[45] LDB[46] LDB[47] LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53]
+ LDB[54] LDB[55] LDB[56] LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62]
+ LDB[63] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8]
+ LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17]
+ LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26]
+ LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] LDT[32] LDT[33] LDT[34] LDT[35]
+ LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43] LDT[44]
+ LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52] LDT[53]
+ LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61] LDT[62]
+ LDT[63] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1]
+ RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2]
+ RLDT[3] RMO[0] RMO[1] RMO[2] VSB[1] VSB[2] VSB[3] VSB[4] WMO[0] WMO[1]
+ WMO[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2]
+ XC[3] XWB[0] XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] VSS VDDA
+ PWR VSSX CSH_LD GRST CSH_RR ag_ctrl BPUI ZRR LRST WLRST SPUI RWOUT EN
+ CSH_ENB T0EN ENB RGD RGBW BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6]
+ BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24]
+ BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33]
+ BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42]
+ BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69]
+ BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78]
+ BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87]
+ BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96]
+ BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104]
+ BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112]
+ BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120]
+ BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BBR[128]
+ BBR[129] BBR[130] BBR[131] BBR[132] BBR[133] BBR[134] BBR[135] BBR[136]
+ BBR[137] BBR[138] BBR[139] BBR[140] BBR[141] BBR[142] BBR[143] BBR[144]
+ BBR[145] BBR[146] BBR[147] BBR[148] BBR[149] BBR[150] BBR[151] BBR[152]
+ BBR[153] BBR[154] BBR[155] BBR[156] BBR[157] BBR[158] BBR[159] BBR[160]
+ BBR[161] BBR[162] BBR[163] BBR[164] BBR[165] BBR[166] BBR[167] BBR[168]
+ BBR[169] BBR[170] BBR[171] BBR[172] BBR[173] BBR[174] BBR[175] BBR[176]
+ BBR[177] BBR[178] BBR[179] BBR[180] BBR[181] BBR[182] BBR[183] BBR[184]
+ BBR[185] BBR[186] BBR[187] BBR[188] BBR[189] BBR[190] BBR[191] BBR[192]
+ BBR[193] BBR[194] BBR[195] BBR[196] BBR[197] BBR[198] BBR[199] BBR[200]
+ BBR[201] BBR[202] BBR[203] BBR[204] BBR[205] BBR[206] BBR[207] BBR[208]
+ BBR[209] BBR[210] BBR[211] BBR[212] BBR[213] BBR[214] BBR[215] BBR[216]
+ BBR[217] BBR[218] BBR[219] BBR[220] BBR[221] BBR[222] BBR[223] BBR[224]
+ BBR[225] BBR[226] BBR[227] BBR[228] BBR[229] BBR[230] BBR[231] BBR[232]
+ BBR[233] BBR[234] BBR[235] BBR[236] BBR[237] BBR[238] BBR[239] BBR[240]
+ BBR[241] BBR[242] BBR[243] BBR[244] BBR[245] BBR[246] BBR[247] BBR[248]
+ BBR[249] BBR[250] BBR[251] BBR[252] BBR[253] BBR[254] BBR[255] BTR[0]
+ BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10]
+ BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19]
+ BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28]
+ BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37]
+ BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46]
+ BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55]
+ BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82]
+ BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91]
+ BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127] BTR[128] BTR[129] BTR[130] BTR[131] BTR[132]
+ BTR[133] BTR[134] BTR[135] BTR[136] BTR[137] BTR[138] BTR[139] BTR[140]
+ BTR[141] BTR[142] BTR[143] BTR[144] BTR[145] BTR[146] BTR[147] BTR[148]
+ BTR[149] BTR[150] BTR[151] BTR[152] BTR[153] BTR[154] BTR[155] BTR[156]
+ BTR[157] BTR[158] BTR[159] BTR[160] BTR[161] BTR[162] BTR[163] BTR[164]
+ BTR[165] BTR[166] BTR[167] BTR[168] BTR[169] BTR[170] BTR[171] BTR[172]
+ BTR[173] BTR[174] BTR[175] BTR[176] BTR[177] BTR[178] BTR[179] BTR[180]
+ BTR[181] BTR[182] BTR[183] BTR[184] BTR[185] BTR[186] BTR[187] BTR[188]
+ BTR[189] BTR[190] BTR[191] BTR[192] BTR[193] BTR[194] BTR[195] BTR[196]
+ BTR[197] BTR[198] BTR[199] BTR[200] BTR[201] BTR[202] BTR[203] BTR[204]
+ BTR[205] BTR[206] BTR[207] BTR[208] BTR[209] BTR[210] BTR[211] BTR[212]
+ BTR[213] BTR[214] BTR[215] BTR[216] BTR[217] BTR[218] BTR[219] BTR[220]
+ BTR[221] BTR[222] BTR[223] BTR[224] BTR[225] BTR[226] BTR[227] BTR[228]
+ BTR[229] BTR[230] BTR[231] BTR[232] BTR[233] BTR[234] BTR[235] BTR[236]
+ BTR[237] BTR[238] BTR[239] BTR[240] BTR[241] BTR[242] BTR[243] BTR[244]
+ BTR[245] BTR[246] BTR[247] BTR[248] BTR[249] BTR[250] BTR[251] BTR[252]
+ BTR[253] BTR[254] BTR[255] LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3] RBB_R[0]
+ RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8]
+ RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15]
+ RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7]
+ RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14]
+ RBT_R[15] XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2] XARLSBA_R[3] XARMSBA_R[0]
+ XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] XARMSBB_R[0] XARMSBB_R[1]
+ XARMSBB_R[2] XARMSBB_R[3] XZB[0] DBL0 LCLKB
*.pininfo BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B BBMX[16]:B BBMX[17]:B
*.pininfo BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B
*.pininfo BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B BBMX[28]:B BBMX[29]:B
*.pininfo BBMX[30]:B BBMX[31]:B BBMX[32]:B BBMX[33]:B BBMX[34]:B BBMX[35]:B
*.pininfo BBMX[36]:B BBMX[37]:B BBMX[38]:B BBMX[39]:B BBMX[40]:B BBMX[41]:B
*.pininfo BBMX[42]:B BBMX[43]:B BBMX[44]:B BBMX[45]:B BBMX[46]:B BBMX[47]:B
*.pininfo BBMX[48]:B BBMX[49]:B BBMX[50]:B BBMX[51]:B BBMX[52]:B BBMX[53]:B
*.pininfo BBMX[54]:B BBMX[55]:B BBMX[56]:B BBMX[57]:B BBMX[58]:B BBMX[59]:B
*.pininfo BBMX[60]:B BBMX[61]:B BBMX[62]:B BBMX[63]:B BTMX[0]:B BTMX[1]:B
*.pininfo BTMX[2]:B BTMX[3]:B BTMX[4]:B BTMX[5]:B BTMX[6]:B BTMX[7]:B
*.pininfo BTMX[8]:B BTMX[9]:B BTMX[10]:B BTMX[11]:B BTMX[12]:B BTMX[13]:B
*.pininfo BTMX[14]:B BTMX[15]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B BTMX[19]:B
*.pininfo BTMX[20]:B BTMX[21]:B BTMX[22]:B BTMX[23]:B BTMX[24]:B BTMX[25]:B
*.pininfo BTMX[26]:B BTMX[27]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B BTMX[31]:B
*.pininfo BTMX[32]:B BTMX[33]:B BTMX[34]:B BTMX[35]:B BTMX[36]:B BTMX[37]:B
*.pininfo BTMX[38]:B BTMX[39]:B BTMX[40]:B BTMX[41]:B BTMX[42]:B BTMX[43]:B
*.pininfo BTMX[44]:B BTMX[45]:B BTMX[46]:B BTMX[47]:B BTMX[48]:B BTMX[49]:B
*.pininfo BTMX[50]:B BTMX[51]:B BTMX[52]:B BTMX[53]:B BTMX[54]:B BTMX[55]:B
*.pininfo BTMX[56]:B BTMX[57]:B BTMX[58]:B BTMX[59]:B BTMX[60]:B BTMX[61]:B
*.pininfo BTMX[62]:B BTMX[63]:B CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B
*.pininfo CSH_YS[3]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B
*.pininfo GBW[6]:B GBW[7]:B GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B
*.pininfo GBW[13]:B GBW[14]:B GBW[15]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B
*.pininfo GD[12]:B GD[13]:B GD[14]:B GD[15]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD0[32]:B
*.pininfo GRD0[33]:B GRD0[34]:B GRD0[35]:B GRD0[36]:B GRD0[37]:B GRD0[38]:B
*.pininfo GRD0[39]:B GRD0[40]:B GRD0[41]:B GRD0[42]:B GRD0[43]:B GRD0[44]:B
*.pininfo GRD0[45]:B GRD0[46]:B GRD0[47]:B GRD0[48]:B GRD0[49]:B GRD0[50]:B
*.pininfo GRD0[51]:B GRD0[52]:B GRD0[53]:B GRD0[54]:B GRD0[55]:B GRD0[56]:B
*.pininfo GRD0[57]:B GRD0[58]:B GRD0[59]:B GRD0[60]:B GRD0[61]:B GRD0[62]:B
*.pininfo GRD0[63]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD1[32]:B GRD1[33]:B GRD1[34]:B
*.pininfo GRD1[35]:B GRD1[36]:B GRD1[37]:B GRD1[38]:B GRD1[39]:B GRD1[40]:B
*.pininfo GRD1[41]:B GRD1[42]:B GRD1[43]:B GRD1[44]:B GRD1[45]:B GRD1[46]:B
*.pininfo GRD1[47]:B GRD1[48]:B GRD1[49]:B GRD1[50]:B GRD1[51]:B GRD1[52]:B
*.pininfo GRD1[53]:B GRD1[54]:B GRD1[55]:B GRD1[56]:B GRD1[57]:B GRD1[58]:B
*.pininfo GRD1[59]:B GRD1[60]:B GRD1[61]:B GRD1[62]:B GRD1[63]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B
*.pininfo GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B
*.pininfo GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B
*.pininfo GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B
*.pininfo GRD2[31]:B GRD2[32]:B GRD2[33]:B GRD2[34]:B GRD2[35]:B GRD2[36]:B
*.pininfo GRD2[37]:B GRD2[38]:B GRD2[39]:B GRD2[40]:B GRD2[41]:B GRD2[42]:B
*.pininfo GRD2[43]:B GRD2[44]:B GRD2[45]:B GRD2[46]:B GRD2[47]:B GRD2[48]:B
*.pininfo GRD2[49]:B GRD2[50]:B GRD2[51]:B GRD2[52]:B GRD2[53]:B GRD2[54]:B
*.pininfo GRD2[55]:B GRD2[56]:B GRD2[57]:B GRD2[58]:B GRD2[59]:B GRD2[60]:B
*.pininfo GRD2[61]:B GRD2[62]:B GRD2[63]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B GRD3[32]:B
*.pininfo GRD3[33]:B GRD3[34]:B GRD3[35]:B GRD3[36]:B GRD3[37]:B GRD3[38]:B
*.pininfo GRD3[39]:B GRD3[40]:B GRD3[41]:B GRD3[42]:B GRD3[43]:B GRD3[44]:B
*.pininfo GRD3[45]:B GRD3[46]:B GRD3[47]:B GRD3[48]:B GRD3[49]:B GRD3[50]:B
*.pininfo GRD3[51]:B GRD3[52]:B GRD3[53]:B GRD3[54]:B GRD3[55]:B GRD3[56]:B
*.pininfo GRD3[57]:B GRD3[58]:B GRD3[59]:B GRD3[60]:B GRD3[61]:B GRD3[62]:B
*.pininfo GRD3[63]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDB[4]:B LDB[5]:B
*.pininfo LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B LDB[12]:B
*.pininfo LDB[13]:B LDB[14]:B LDB[15]:B LDB[16]:B LDB[17]:B LDB[18]:B
*.pininfo LDB[19]:B LDB[20]:B LDB[21]:B LDB[22]:B LDB[23]:B LDB[24]:B
*.pininfo LDB[25]:B LDB[26]:B LDB[27]:B LDB[28]:B LDB[29]:B LDB[30]:B
*.pininfo LDB[31]:B LDB[32]:B LDB[33]:B LDB[34]:B LDB[35]:B LDB[36]:B
*.pininfo LDB[37]:B LDB[38]:B LDB[39]:B LDB[40]:B LDB[41]:B LDB[42]:B
*.pininfo LDB[43]:B LDB[44]:B LDB[45]:B LDB[46]:B LDB[47]:B LDB[48]:B
*.pininfo LDB[49]:B LDB[50]:B LDB[51]:B LDB[52]:B LDB[53]:B LDB[54]:B
*.pininfo LDB[55]:B LDB[56]:B LDB[57]:B LDB[58]:B LDB[59]:B LDB[60]:B
*.pininfo LDB[61]:B LDB[62]:B LDB[63]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B
*.pininfo LDT[4]:B LDT[5]:B LDT[6]:B LDT[7]:B LDT[8]:B LDT[9]:B LDT[10]:B
*.pininfo LDT[11]:B LDT[12]:B LDT[13]:B LDT[14]:B LDT[15]:B LDT[16]:B
*.pininfo LDT[17]:B LDT[18]:B LDT[19]:B LDT[20]:B LDT[21]:B LDT[22]:B
*.pininfo LDT[23]:B LDT[24]:B LDT[25]:B LDT[26]:B LDT[27]:B LDT[28]:B
*.pininfo LDT[29]:B LDT[30]:B LDT[31]:B LDT[32]:B LDT[33]:B LDT[34]:B
*.pininfo LDT[35]:B LDT[36]:B LDT[37]:B LDT[38]:B LDT[39]:B LDT[40]:B
*.pininfo LDT[41]:B LDT[42]:B LDT[43]:B LDT[44]:B LDT[45]:B LDT[46]:B
*.pininfo LDT[47]:B LDT[48]:B LDT[49]:B LDT[50]:B LDT[51]:B LDT[52]:B
*.pininfo LDT[53]:B LDT[54]:B LDT[55]:B LDT[56]:B LDT[57]:B LDT[58]:B
*.pininfo LDT[59]:B LDT[60]:B LDT[61]:B LDT[62]:B LDT[63]:B QT[2]:B QT[3]:B
*.pininfo QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B
*.pininfo QT[12]:B QT[13]:B RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B RBBMX[3]:B
*.pininfo RBTMX[0]:B RBTMX[1]:B RBTMX[2]:B RBTMX[3]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B
*.pininfo RGRD3[2]:B RGRD3[3]:B RLDB[0]:B RLDB[1]:B RLDB[2]:B RLDB[3]:B
*.pininfo RLDT[0]:B RLDT[1]:B RLDT[2]:B RLDT[3]:B RMO[0]:B RMO[1]:B RMO[2]:B
*.pininfo VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B WMO[0]:B WMO[1]:B WMO[2]:B
*.pininfo XA[0]:B XA[1]:B XA[2]:B XA[3]:B XB[0]:B XB[1]:B XB[2]:B XB[3]:B
*.pininfo XC[0]:B XC[1]:B XC[2]:B XC[3]:B XWB[0]:B XWB[1]:B XWB[2]:B XWB[3]:B
*.pininfo YSEL[0]:B YSEL[1]:B YSEL[2]:B YSEL[3]:B VSS:B VDDA:B PWR:B VSSX:B
*.pininfo CSH_LD:B GRST:B CSH_RR:B ag_ctrl:B BPUI:B ZRR:B LRST:B WLRST:B
*.pininfo SPUI:B RWOUT:B EN:B CSH_ENB:B T0EN:B ENB:B RGD:B RGBW:B BBR[0]:B
*.pininfo BBR[1]:B BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B BBR[7]:B
*.pininfo BBR[8]:B BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B BBR[14]:B
*.pininfo BBR[15]:B BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B BBR[20]:B
*.pininfo BBR[21]:B BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B BBR[26]:B
*.pininfo BBR[27]:B BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B BBR[32]:B
*.pininfo BBR[33]:B BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B BBR[38]:B
*.pininfo BBR[39]:B BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B BBR[44]:B
*.pininfo BBR[45]:B BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B BBR[50]:B
*.pininfo BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B BBR[56]:B
*.pininfo BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B BBR[62]:B
*.pininfo BBR[63]:B BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B BBR[68]:B
*.pininfo BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B BBR[74]:B
*.pininfo BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B BBR[80]:B
*.pininfo BBR[81]:B BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B BBR[86]:B
*.pininfo BBR[87]:B BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B BBR[92]:B
*.pininfo BBR[93]:B BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B BBR[98]:B
*.pininfo BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B BBR[104]:B
*.pininfo BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B BBR[110]:B
*.pininfo BBR[111]:B BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B BBR[116]:B
*.pininfo BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B BBR[122]:B
*.pininfo BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B BBR[128]:B
*.pininfo BBR[129]:B BBR[130]:B BBR[131]:B BBR[132]:B BBR[133]:B BBR[134]:B
*.pininfo BBR[135]:B BBR[136]:B BBR[137]:B BBR[138]:B BBR[139]:B BBR[140]:B
*.pininfo BBR[141]:B BBR[142]:B BBR[143]:B BBR[144]:B BBR[145]:B BBR[146]:B
*.pininfo BBR[147]:B BBR[148]:B BBR[149]:B BBR[150]:B BBR[151]:B BBR[152]:B
*.pininfo BBR[153]:B BBR[154]:B BBR[155]:B BBR[156]:B BBR[157]:B BBR[158]:B
*.pininfo BBR[159]:B BBR[160]:B BBR[161]:B BBR[162]:B BBR[163]:B BBR[164]:B
*.pininfo BBR[165]:B BBR[166]:B BBR[167]:B BBR[168]:B BBR[169]:B BBR[170]:B
*.pininfo BBR[171]:B BBR[172]:B BBR[173]:B BBR[174]:B BBR[175]:B BBR[176]:B
*.pininfo BBR[177]:B BBR[178]:B BBR[179]:B BBR[180]:B BBR[181]:B BBR[182]:B
*.pininfo BBR[183]:B BBR[184]:B BBR[185]:B BBR[186]:B BBR[187]:B BBR[188]:B
*.pininfo BBR[189]:B BBR[190]:B BBR[191]:B BBR[192]:B BBR[193]:B BBR[194]:B
*.pininfo BBR[195]:B BBR[196]:B BBR[197]:B BBR[198]:B BBR[199]:B BBR[200]:B
*.pininfo BBR[201]:B BBR[202]:B BBR[203]:B BBR[204]:B BBR[205]:B BBR[206]:B
*.pininfo BBR[207]:B BBR[208]:B BBR[209]:B BBR[210]:B BBR[211]:B BBR[212]:B
*.pininfo BBR[213]:B BBR[214]:B BBR[215]:B BBR[216]:B BBR[217]:B BBR[218]:B
*.pininfo BBR[219]:B BBR[220]:B BBR[221]:B BBR[222]:B BBR[223]:B BBR[224]:B
*.pininfo BBR[225]:B BBR[226]:B BBR[227]:B BBR[228]:B BBR[229]:B BBR[230]:B
*.pininfo BBR[231]:B BBR[232]:B BBR[233]:B BBR[234]:B BBR[235]:B BBR[236]:B
*.pininfo BBR[237]:B BBR[238]:B BBR[239]:B BBR[240]:B BBR[241]:B BBR[242]:B
*.pininfo BBR[243]:B BBR[244]:B BBR[245]:B BBR[246]:B BBR[247]:B BBR[248]:B
*.pininfo BBR[249]:B BBR[250]:B BBR[251]:B BBR[252]:B BBR[253]:B BBR[254]:B
*.pininfo BBR[255]:B BTR[0]:B BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B BTR[5]:B
*.pininfo BTR[6]:B BTR[7]:B BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B BTR[12]:B
*.pininfo BTR[13]:B BTR[14]:B BTR[15]:B BTR[16]:B BTR[17]:B BTR[18]:B
*.pininfo BTR[19]:B BTR[20]:B BTR[21]:B BTR[22]:B BTR[23]:B BTR[24]:B
*.pininfo BTR[25]:B BTR[26]:B BTR[27]:B BTR[28]:B BTR[29]:B BTR[30]:B
*.pininfo BTR[31]:B BTR[32]:B BTR[33]:B BTR[34]:B BTR[35]:B BTR[36]:B
*.pininfo BTR[37]:B BTR[38]:B BTR[39]:B BTR[40]:B BTR[41]:B BTR[42]:B
*.pininfo BTR[43]:B BTR[44]:B BTR[45]:B BTR[46]:B BTR[47]:B BTR[48]:B
*.pininfo BTR[49]:B BTR[50]:B BTR[51]:B BTR[52]:B BTR[53]:B BTR[54]:B
*.pininfo BTR[55]:B BTR[56]:B BTR[57]:B BTR[58]:B BTR[59]:B BTR[60]:B
*.pininfo BTR[61]:B BTR[62]:B BTR[63]:B BTR[64]:B BTR[65]:B BTR[66]:B
*.pininfo BTR[67]:B BTR[68]:B BTR[69]:B BTR[70]:B BTR[71]:B BTR[72]:B
*.pininfo BTR[73]:B BTR[74]:B BTR[75]:B BTR[76]:B BTR[77]:B BTR[78]:B
*.pininfo BTR[79]:B BTR[80]:B BTR[81]:B BTR[82]:B BTR[83]:B BTR[84]:B
*.pininfo BTR[85]:B BTR[86]:B BTR[87]:B BTR[88]:B BTR[89]:B BTR[90]:B
*.pininfo BTR[91]:B BTR[92]:B BTR[93]:B BTR[94]:B BTR[95]:B BTR[96]:B
*.pininfo BTR[97]:B BTR[98]:B BTR[99]:B BTR[100]:B BTR[101]:B BTR[102]:B
*.pininfo BTR[103]:B BTR[104]:B BTR[105]:B BTR[106]:B BTR[107]:B BTR[108]:B
*.pininfo BTR[109]:B BTR[110]:B BTR[111]:B BTR[112]:B BTR[113]:B BTR[114]:B
*.pininfo BTR[115]:B BTR[116]:B BTR[117]:B BTR[118]:B BTR[119]:B BTR[120]:B
*.pininfo BTR[121]:B BTR[122]:B BTR[123]:B BTR[124]:B BTR[125]:B BTR[126]:B
*.pininfo BTR[127]:B BTR[128]:B BTR[129]:B BTR[130]:B BTR[131]:B BTR[132]:B
*.pininfo BTR[133]:B BTR[134]:B BTR[135]:B BTR[136]:B BTR[137]:B BTR[138]:B
*.pininfo BTR[139]:B BTR[140]:B BTR[141]:B BTR[142]:B BTR[143]:B BTR[144]:B
*.pininfo BTR[145]:B BTR[146]:B BTR[147]:B BTR[148]:B BTR[149]:B BTR[150]:B
*.pininfo BTR[151]:B BTR[152]:B BTR[153]:B BTR[154]:B BTR[155]:B BTR[156]:B
*.pininfo BTR[157]:B BTR[158]:B BTR[159]:B BTR[160]:B BTR[161]:B BTR[162]:B
*.pininfo BTR[163]:B BTR[164]:B BTR[165]:B BTR[166]:B BTR[167]:B BTR[168]:B
*.pininfo BTR[169]:B BTR[170]:B BTR[171]:B BTR[172]:B BTR[173]:B BTR[174]:B
*.pininfo BTR[175]:B BTR[176]:B BTR[177]:B BTR[178]:B BTR[179]:B BTR[180]:B
*.pininfo BTR[181]:B BTR[182]:B BTR[183]:B BTR[184]:B BTR[185]:B BTR[186]:B
*.pininfo BTR[187]:B BTR[188]:B BTR[189]:B BTR[190]:B BTR[191]:B BTR[192]:B
*.pininfo BTR[193]:B BTR[194]:B BTR[195]:B BTR[196]:B BTR[197]:B BTR[198]:B
*.pininfo BTR[199]:B BTR[200]:B BTR[201]:B BTR[202]:B BTR[203]:B BTR[204]:B
*.pininfo BTR[205]:B BTR[206]:B BTR[207]:B BTR[208]:B BTR[209]:B BTR[210]:B
*.pininfo BTR[211]:B BTR[212]:B BTR[213]:B BTR[214]:B BTR[215]:B BTR[216]:B
*.pininfo BTR[217]:B BTR[218]:B BTR[219]:B BTR[220]:B BTR[221]:B BTR[222]:B
*.pininfo BTR[223]:B BTR[224]:B BTR[225]:B BTR[226]:B BTR[227]:B BTR[228]:B
*.pininfo BTR[229]:B BTR[230]:B BTR[231]:B BTR[232]:B BTR[233]:B BTR[234]:B
*.pininfo BTR[235]:B BTR[236]:B BTR[237]:B BTR[238]:B BTR[239]:B BTR[240]:B
*.pininfo BTR[241]:B BTR[242]:B BTR[243]:B BTR[244]:B BTR[245]:B BTR[246]:B
*.pininfo BTR[247]:B BTR[248]:B BTR[249]:B BTR[250]:B BTR[251]:B BTR[252]:B
*.pininfo BTR[253]:B BTR[254]:B BTR[255]:B LXWB_R[0]:O LXWB_R[1]:O
*.pininfo LXWB_R[2]:O LXWB_R[3]:O RBB_R[0]:B RBB_R[1]:B RBB_R[2]:B RBB_R[3]:B
*.pininfo RBB_R[4]:B RBB_R[5]:B RBB_R[6]:B RBB_R[7]:B RBB_R[8]:B RBB_R[9]:B
*.pininfo RBB_R[10]:B RBB_R[11]:B RBB_R[12]:B RBB_R[13]:B RBB_R[14]:B
*.pininfo RBB_R[15]:B RBT_R[0]:B RBT_R[1]:B RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B
*.pininfo RBT_R[5]:B RBT_R[6]:B RBT_R[7]:B RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B
*.pininfo RBT_R[11]:B RBT_R[12]:B RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B
*.pininfo XARLSBA_R[0]:O XARLSBA_R[1]:O XARLSBA_R[2]:O XARLSBA_R[3]:O
*.pininfo XARMSBA_R[0]:O XARMSBA_R[1]:O XARMSBA_R[2]:O XARMSBA_R[3]:O
*.pininfo XARMSBB_R[0]:O XARMSBB_R[1]:O XARMSBB_R[2]:O XARMSBB_R[3]:O
*.pininfo XZB[0]:I DBL0:B LCLKB:B
XXBNK1_SLIO BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4] BBMX[5] BBMX[6] BBMX[7]
+ BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13] BBMX[14] BBMX[15]
+ BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21] BBMX[22] BBMX[23]
+ BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29] BBMX[30] BBMX[31]
+ BBMX[32] BBMX[33] BBMX[34] BBMX[35] BBMX[36] BBMX[37] BBMX[38] BBMX[39]
+ BBMX[40] BBMX[41] BBMX[42] BBMX[43] BBMX[44] BBMX[45] BBMX[46] BBMX[47]
+ BBMX[48] BBMX[49] BBMX[50] BBMX[51] BBMX[52] BBMX[53] BBMX[54] BBMX[55]
+ BBMX[56] BBMX[57] BBMX[58] BBMX[59] BBMX[60] BBMX[61] BBMX[62] BBMX[63]
+ BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6] BTMX[7] BTMX[8]
+ BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14] BTMX[15] BTMX[16]
+ BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22] BTMX[23] BTMX[24]
+ BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30] BTMX[31] BTMX[32]
+ BTMX[33] BTMX[34] BTMX[35] BTMX[36] BTMX[37] BTMX[38] BTMX[39] BTMX[40]
+ BTMX[41] BTMX[42] BTMX[43] BTMX[44] BTMX[45] BTMX[46] BTMX[47] BTMX[48]
+ BTMX[49] BTMX[50] BTMX[51] BTMX[52] BTMX[53] BTMX[54] BTMX[55] BTMX[56]
+ BTMX[57] BTMX[58] BTMX[59] BTMX[60] BTMX[61] BTMX[62] BTMX[63] CSH_YS[0]
+ CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5]
+ GBW[6] GBW[7] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15]
+ GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GD[8] GD[9] GD[10] GD[11]
+ GD[12] GD[13] GD[14] GD[15] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5]
+ GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37]
+ GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45]
+ GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53]
+ GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61]
+ GRD0[62] GRD0[63] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38]
+ GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46]
+ GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54]
+ GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62]
+ GRD1[63] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39]
+ GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47]
+ GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55]
+ GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] GRD3[32]
+ GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40]
+ GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48]
+ GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56]
+ GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] LDB[0]
+ LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8] LDB[9] LDB[10]
+ LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17] LDB[18] LDB[19]
+ LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26] LDB[27] LDB[28]
+ LDB[29] LDB[30] LDB[31] LDB[32] LDB[33] LDB[34] LDB[35] LDB[36] LDB[37]
+ LDB[38] LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44] LDB[45] LDB[46]
+ LDB[47] LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53] LDB[54] LDB[55]
+ LDB[56] LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62] LDB[63] LDT[0]
+ LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8] LDT[9] LDT[10]
+ LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17] LDT[18] LDT[19]
+ LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26] LDT[27] LDT[28]
+ LDT[29] LDT[30] LDT[31] LDT[32] LDT[33] LDT[34] LDT[35] LDT[36] LDT[37]
+ LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43] LDT[44] LDT[45] LDT[46]
+ LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52] LDT[53] LDT[54] LDT[55]
+ LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61] LDT[62] LDT[63] QT[2] QT[3]
+ QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RBBMX[0]
+ RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1] RBTMX[2] RBTMX[3] RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0]
+ RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RLDB[0]
+ RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2] RLDT[3] RMO[0] RMO[1]
+ RMO[2] VSB[1] VSB[2] VSB[3] VSB[4] WMO[0] WMO[1] WMO[2] XA[0] XA[1] XA[2]
+ XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2] XC[3] XWB[0] XWB[1] XWB[2]
+ XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] VSS VDDA PWR VSSX CSH_LD GRST CSH_RR
+ ag_ctrl BPUI ZRR LRST WLRST VDDA SPUI RWOUT EN CSH_ENB T0EN ENB RGD RGBW
+ BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8] BBR[9]
+ BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBR[16] BBR[17] BBR[18]
+ BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26] BBR[27]
+ BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33] BBR[34] BBR[35] BBR[36]
+ BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44] BBR[45]
+ BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52] BBR[53] BBR[54]
+ BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61] BBR[62] BBR[63]
+ BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71] BBR[72]
+ BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BBR[80] BBR[81]
+ BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89] BBR[90]
+ BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96] BBR[97] BBR[98] BBR[99]
+ BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106] BBR[107]
+ BBR[108] BBR[109] BBR[110] BBR[111] BBR[112] BBR[113] BBR[114] BBR[115]
+ BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122] BBR[123]
+ BBR[124] BBR[125] BBR[126] BBR[127] BBR[128] BBR[129] BBR[130] BBR[131]
+ BBR[132] BBR[133] BBR[134] BBR[135] BBR[136] BBR[137] BBR[138] BBR[139]
+ BBR[140] BBR[141] BBR[142] BBR[143] BBR[144] BBR[145] BBR[146] BBR[147]
+ BBR[148] BBR[149] BBR[150] BBR[151] BBR[152] BBR[153] BBR[154] BBR[155]
+ BBR[156] BBR[157] BBR[158] BBR[159] BBR[160] BBR[161] BBR[162] BBR[163]
+ BBR[164] BBR[165] BBR[166] BBR[167] BBR[168] BBR[169] BBR[170] BBR[171]
+ BBR[172] BBR[173] BBR[174] BBR[175] BBR[176] BBR[177] BBR[178] BBR[179]
+ BBR[180] BBR[181] BBR[182] BBR[183] BBR[184] BBR[185] BBR[186] BBR[187]
+ BBR[188] BBR[189] BBR[190] BBR[191] BBR[192] BBR[193] BBR[194] BBR[195]
+ BBR[196] BBR[197] BBR[198] BBR[199] BBR[200] BBR[201] BBR[202] BBR[203]
+ BBR[204] BBR[205] BBR[206] BBR[207] BBR[208] BBR[209] BBR[210] BBR[211]
+ BBR[212] BBR[213] BBR[214] BBR[215] BBR[216] BBR[217] BBR[218] BBR[219]
+ BBR[220] BBR[221] BBR[222] BBR[223] BBR[224] BBR[225] BBR[226] BBR[227]
+ BBR[228] BBR[229] BBR[230] BBR[231] BBR[232] BBR[233] BBR[234] BBR[235]
+ BBR[236] BBR[237] BBR[238] BBR[239] BBR[240] BBR[241] BBR[242] BBR[243]
+ BBR[244] BBR[245] BBR[246] BBR[247] BBR[248] BBR[249] BBR[250] BBR[251]
+ BBR[252] BBR[253] BBR[254] BBR[255] BTR[0] BTR[1] BTR[2] BTR[3] BTR[4]
+ BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13] BTR[14]
+ BTR[15] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22] BTR[23]
+ BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31] BTR[32]
+ BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40] BTR[41]
+ BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] BTR[48] BTR[49] BTR[50]
+ BTR[51] BTR[52] BTR[53] BTR[54] BTR[55] BTR[56] BTR[57] BTR[58] BTR[59]
+ BTR[60] BTR[61] BTR[62] BTR[63] BTR[64] BTR[65] BTR[66] BTR[67] BTR[68]
+ BTR[69] BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76] BTR[77]
+ BTR[78] BTR[79] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85] BTR[86]
+ BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94] BTR[95]
+ BTR[96] BTR[97] BTR[98] BTR[99] BTR[100] BTR[101] BTR[102] BTR[103]
+ BTR[104] BTR[105] BTR[106] BTR[107] BTR[108] BTR[109] BTR[110] BTR[111]
+ BTR[112] BTR[113] BTR[114] BTR[115] BTR[116] BTR[117] BTR[118] BTR[119]
+ BTR[120] BTR[121] BTR[122] BTR[123] BTR[124] BTR[125] BTR[126] BTR[127]
+ BTR[128] BTR[129] BTR[130] BTR[131] BTR[132] BTR[133] BTR[134] BTR[135]
+ BTR[136] BTR[137] BTR[138] BTR[139] BTR[140] BTR[141] BTR[142] BTR[143]
+ BTR[144] BTR[145] BTR[146] BTR[147] BTR[148] BTR[149] BTR[150] BTR[151]
+ BTR[152] BTR[153] BTR[154] BTR[155] BTR[156] BTR[157] BTR[158] BTR[159]
+ BTR[160] BTR[161] BTR[162] BTR[163] BTR[164] BTR[165] BTR[166] BTR[167]
+ BTR[168] BTR[169] BTR[170] BTR[171] BTR[172] BTR[173] BTR[174] BTR[175]
+ BTR[176] BTR[177] BTR[178] BTR[179] BTR[180] BTR[181] BTR[182] BTR[183]
+ BTR[184] BTR[185] BTR[186] BTR[187] BTR[188] BTR[189] BTR[190] BTR[191]
+ BTR[192] BTR[193] BTR[194] BTR[195] BTR[196] BTR[197] BTR[198] BTR[199]
+ BTR[200] BTR[201] BTR[202] BTR[203] BTR[204] BTR[205] BTR[206] BTR[207]
+ BTR[208] BTR[209] BTR[210] BTR[211] BTR[212] BTR[213] BTR[214] BTR[215]
+ BTR[216] BTR[217] BTR[218] BTR[219] BTR[220] BTR[221] BTR[222] BTR[223]
+ BTR[224] BTR[225] BTR[226] BTR[227] BTR[228] BTR[229] BTR[230] BTR[231]
+ BTR[232] BTR[233] BTR[234] BTR[235] BTR[236] BTR[237] BTR[238] BTR[239]
+ BTR[240] BTR[241] BTR[242] BTR[243] BTR[244] BTR[245] BTR[246] BTR[247]
+ BTR[248] BTR[249] BTR[250] BTR[251] BTR[252] BTR[253] BTR[254] BTR[255]
+ LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3] RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3]
+ RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11]
+ RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3]
+ RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11]
+ RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15] XARLSBA_R[0] XARLSBA_R[1]
+ XARLSBA_R[2] XARLSBA_R[3] XARMSBA_R[0] XARMSBA_R[1] XARMSBA_R[2]
+ XARMSBA_R[3] XARMSBB_R[0] XARMSBB_R[1] XARMSBB_R[2] XARMSBB_R[3] XZB[0]
+ DBL0 LCLKB spram_4096x16m16b1pm2re1PM2M16B1 m=1
.ends spram_4096x16m16b1pm2re1BNK1_SLIO

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_EDG_R VDDA VSSX VSS VNW
+ PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10]
+ WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+ WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30]
+ WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40]
+ WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50]
+ WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+ WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70]
+ WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80]
+ WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90]
+ WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100]
+ WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109]
+ WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118]
+ WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127]
+ WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136]
+ WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145]
+ WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154]
+ WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163]
+ WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172]
+ WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181]
+ WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190]
+ WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199]
+ WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208]
+ WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217]
+ WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226]
+ WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235]
+ WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244]
+ WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253]
+ WL[254] WL[255] RWL
*.pininfo VDDA:B VSSX:B VSS:B VNW:B PWR:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.pininfo WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B
*.pininfo WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B
*.pininfo WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B
*.pininfo WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B
*.pininfo WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B
*.pininfo WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B
*.pininfo WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B
*.pininfo WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B
*.pininfo WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B
*.pininfo WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B
*.pininfo WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B
*.pininfo WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B
*.pininfo WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B
*.pininfo WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B
*.pininfo WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B
*.pininfo WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B
*.pininfo WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B
*.pininfo WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B
*.pininfo WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B
*.pininfo WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B
*.pininfo WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B
*.pininfo WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B
*.pininfo WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B
*.pininfo WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B
*.pininfo WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B
*.pininfo WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B
*.pininfo WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B
*.pininfo WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B
*.pininfo WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B
*.pininfo WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B
*.pininfo WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B
*.pininfo WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B
*.pininfo WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B
*.pininfo WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B
*.pininfo WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B
*.pininfo WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B
*.pininfo WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B
*.pininfo WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B
*.pininfo WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B
*.pininfo WL[253]:B WL[254]:B WL[255]:B RWL:B
XXc0r0 PWR VDDA VNW VSS VSSX bitcell_edge_cap m=1
XXc1r0 PWR VDDA VNW VSS VSSX WL[0] WL[1] WL[2] WL[3] bitcell_edge m=1
XXc2r0 PWR VDDA VNW VSS VSSX WL[4] WL[5] WL[6] WL[7] bitcell_edge m=1
XXc3r0 PWR VDDA VNW VSS VSSX WL[8] WL[9] WL[10] WL[11] bitcell_edge m=1
XXc4r0 PWR VDDA VNW VSS VSSX WL[12] WL[13] WL[14] WL[15] bitcell_edge m=1
XXc5r0 PWR VDDA VNW VSS VSSX WL[16] WL[17] WL[18] WL[19] bitcell_edge m=1
XXc6r0 PWR VDDA VNW VSS VSSX WL[20] WL[21] WL[22] WL[23] bitcell_edge m=1
XXc7r0 PWR VDDA VNW VSS VSSX WL[24] WL[25] WL[26] WL[27] bitcell_edge m=1
XXc8r0 PWR VDDA VNW VSS VSSX WL[28] WL[29] WL[30] WL[31] bitcell_edge m=1
XXc9r0 PWR VDDA VNW VSS VSSX WL[32] WL[33] WL[34] WL[35] bitcell_edge m=1
XXc10r0 PWR VDDA VNW VSS VSSX WL[36] WL[37] WL[38] WL[39] bitcell_edge m=1
XXc11r0 PWR VDDA VNW VSS VSSX WL[40] WL[41] WL[42] WL[43] bitcell_edge m=1
XXc12r0 PWR VDDA VNW VSS VSSX WL[44] WL[45] WL[46] WL[47] bitcell_edge m=1
XXc13r0 PWR VDDA VNW VSS VSSX WL[48] WL[49] WL[50] WL[51] bitcell_edge m=1
XXc14r0 PWR VDDA VNW VSS VSSX WL[52] WL[53] WL[54] WL[55] bitcell_edge m=1
XXc15r0 PWR VDDA VNW VSS VSSX WL[56] WL[57] WL[58] WL[59] bitcell_edge m=1
XXc16r0 PWR VDDA VNW VSS VSSX WL[60] WL[61] WL[62] WL[63] bitcell_edge m=1
XXc17r0 PWR VDDA VNW VSS VSSX WL[64] WL[65] WL[66] WL[67] bitcell_edge m=1
XXc18r0 PWR VDDA VNW VSS VSSX WL[68] WL[69] WL[70] WL[71] bitcell_edge m=1
XXc19r0 PWR VDDA VNW VSS VSSX WL[72] WL[73] WL[74] WL[75] bitcell_edge m=1
XXc20r0 PWR VDDA VNW VSS VSSX WL[76] WL[77] WL[78] WL[79] bitcell_edge m=1
XXc21r0 PWR VDDA VNW VSS VSSX WL[80] WL[81] WL[82] WL[83] bitcell_edge m=1
XXc22r0 PWR VDDA VNW VSS VSSX WL[84] WL[85] WL[86] WL[87] bitcell_edge m=1
XXc23r0 PWR VDDA VNW VSS VSSX WL[88] WL[89] WL[90] WL[91] bitcell_edge m=1
XXc24r0 PWR VDDA VNW VSS VSSX WL[92] WL[93] WL[94] WL[95] bitcell_edge m=1
XXc25r0 PWR VDDA VNW VSS VSSX WL[96] WL[97] WL[98] WL[99] bitcell_edge m=1
XXc26r0 PWR VDDA VNW VSS VSSX WL[100] WL[101] WL[102] WL[103] bitcell_edge m=1
XXc27r0 PWR VDDA VNW VSS VSSX WL[104] WL[105] WL[106] WL[107] bitcell_edge m=1
XXc28r0 PWR VDDA VNW VSS VSSX WL[108] WL[109] WL[110] WL[111] bitcell_edge m=1
XXc29r0 PWR VDDA VNW VSS VSSX WL[112] WL[113] WL[114] WL[115] bitcell_edge m=1
XXc30r0 PWR VDDA VNW VSS VSSX WL[116] WL[117] WL[118] WL[119] bitcell_edge m=1
XXc31r0 PWR VDDA VNW VSS VSSX WL[120] WL[121] WL[122] WL[123] bitcell_edge m=1
XXc32r0 PWR VDDA VNW VSS VSSX WL[124] WL[125] WL[126] WL[127] bitcell_edge m=1
XXc33r0 PWR VDDA VNW VSS VSSX WL[128] WL[129] WL[130] WL[131] bitcell_edge m=1
XXc34r0 PWR VDDA VNW VSS VSSX WL[132] WL[133] WL[134] WL[135] bitcell_edge m=1
XXc35r0 PWR VDDA VNW VSS VSSX WL[136] WL[137] WL[138] WL[139] bitcell_edge m=1
XXc36r0 PWR VDDA VNW VSS VSSX WL[140] WL[141] WL[142] WL[143] bitcell_edge m=1
XXc37r0 PWR VDDA VNW VSS VSSX WL[144] WL[145] WL[146] WL[147] bitcell_edge m=1
XXc38r0 PWR VDDA VNW VSS VSSX WL[148] WL[149] WL[150] WL[151] bitcell_edge m=1
XXc39r0 PWR VDDA VNW VSS VSSX WL[152] WL[153] WL[154] WL[155] bitcell_edge m=1
XXc40r0 PWR VDDA VNW VSS VSSX WL[156] WL[157] WL[158] WL[159] bitcell_edge m=1
XXc41r0 PWR VDDA VNW VSS VSSX WL[160] WL[161] WL[162] WL[163] bitcell_edge m=1
XXc42r0 PWR VDDA VNW VSS VSSX WL[164] WL[165] WL[166] WL[167] bitcell_edge m=1
XXc43r0 PWR VDDA VNW VSS VSSX WL[168] WL[169] WL[170] WL[171] bitcell_edge m=1
XXc44r0 PWR VDDA VNW VSS VSSX WL[172] WL[173] WL[174] WL[175] bitcell_edge m=1
XXc45r0 PWR VDDA VNW VSS VSSX WL[176] WL[177] WL[178] WL[179] bitcell_edge m=1
XXc46r0 PWR VDDA VNW VSS VSSX WL[180] WL[181] WL[182] WL[183] bitcell_edge m=1
XXc47r0 PWR VDDA VNW VSS VSSX WL[184] WL[185] WL[186] WL[187] bitcell_edge m=1
XXc48r0 PWR VDDA VNW VSS VSSX WL[188] WL[189] WL[190] WL[191] bitcell_edge m=1
XXc49r0 PWR VDDA VNW VSS VSSX WL[192] WL[193] WL[194] WL[195] bitcell_edge m=1
XXc50r0 PWR VDDA VNW VSS VSSX WL[196] WL[197] WL[198] WL[199] bitcell_edge m=1
XXc51r0 PWR VDDA VNW VSS VSSX WL[200] WL[201] WL[202] WL[203] bitcell_edge m=1
XXc52r0 PWR VDDA VNW VSS VSSX WL[204] WL[205] WL[206] WL[207] bitcell_edge m=1
XXc53r0 PWR VDDA VNW VSS VSSX WL[208] WL[209] WL[210] WL[211] bitcell_edge m=1
XXc54r0 PWR VDDA VNW VSS VSSX WL[212] WL[213] WL[214] WL[215] bitcell_edge m=1
XXc55r0 PWR VDDA VNW VSS VSSX WL[216] WL[217] WL[218] WL[219] bitcell_edge m=1
XXc56r0 PWR VDDA VNW VSS VSSX WL[220] WL[221] WL[222] WL[223] bitcell_edge m=1
XXc57r0 PWR VDDA VNW VSS VSSX WL[224] WL[225] WL[226] WL[227] bitcell_edge m=1
XXc58r0 PWR VDDA VNW VSS VSSX WL[228] WL[229] WL[230] WL[231] bitcell_edge m=1
XXc59r0 PWR VDDA VNW VSS VSSX WL[232] WL[233] WL[234] WL[235] bitcell_edge m=1
XXc60r0 PWR VDDA VNW VSS VSSX WL[236] WL[237] WL[238] WL[239] bitcell_edge m=1
XXc61r0 PWR VDDA VNW VSS VSSX WL[240] WL[241] WL[242] WL[243] bitcell_edge m=1
XXc62r0 PWR VDDA VNW VSS VSSX WL[244] WL[245] WL[246] WL[247] bitcell_edge m=1
XXc63r0 PWR VDDA VNW VSS VSSX WL[248] WL[249] WL[250] WL[251] bitcell_edge m=1
XXc64r0 PWR VDDA VNW VSS VSSX WL[252] WL[253] WL[254] WL[255] bitcell_edge m=1
XXc65r0 PWR RWL VDDA VNW VSS VSSX bitcell_edge_tmr_wl m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_EDG_R

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGER VDDA VSSX VSS RWL
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR
*.pininfo VDDA:B VSSX:B VSS:B RWL:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B
*.pininfo WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B
*.pininfo WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B
*.pininfo WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B
*.pininfo WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B
*.pininfo WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B
*.pininfo WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B
*.pininfo WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B
*.pininfo WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B
*.pininfo WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B
*.pininfo WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B
*.pininfo WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B
*.pininfo WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B
*.pininfo WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B
*.pininfo WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B
*.pininfo WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B
*.pininfo WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B
*.pininfo WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B
*.pininfo WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B
*.pininfo WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B
*.pininfo WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B
*.pininfo WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B
*.pininfo WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B
*.pininfo WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B
*.pininfo WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B
*.pininfo WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B
*.pininfo WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B
*.pininfo WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B
*.pininfo WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B
*.pininfo WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B
*.pininfo WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B
*.pininfo WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B
*.pininfo WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B
*.pininfo WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B
*.pininfo WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B
*.pininfo WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B
*.pininfo WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B
*.pininfo WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B
*.pininfo WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B
*.pininfo WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B
*.pininfo WL[254]:B WL[255]:B VNW:B PWR:B
XX00 VDDA VSSX VSS VNW PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7]
+ WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18]
+ WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28]
+ WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38]
+ WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48]
+ WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58]
+ WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68]
+ WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78]
+ WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88]
+ WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98]
+ WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107]
+ WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116]
+ WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125]
+ WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134]
+ WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143]
+ WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152]
+ WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161]
+ WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170]
+ WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179]
+ WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188]
+ WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197]
+ WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206]
+ WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215]
+ WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224]
+ WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233]
+ WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242]
+ WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251]
+ WL[252] WL[253] WL[254] WL[255] RWL
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_EDG_R m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGER

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE GD[0] GBW[0]
+ VSSX GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] BB[0] BB[1]
+ BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+ BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] VNW VSS VDDA PWR WL[0] WL[1]
+ WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL
+ BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6]
+ BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13]
+ BB_TOP[14] BB_TOP[15]
*.pininfo GD[0]:B GBW[0]:B VSSX:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B
*.pininfo BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.pininfo BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.pininfo BT[15]:B VNW:B VSS:B VDDA:B PWR:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.pininfo WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B
*.pininfo WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B
*.pininfo WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B
*.pininfo WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B
*.pininfo WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B
*.pininfo WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B
*.pininfo WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B
*.pininfo WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B
*.pininfo WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B
*.pininfo WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B
*.pininfo WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B
*.pininfo WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B
*.pininfo WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B
*.pininfo WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B
*.pininfo WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B
*.pininfo WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B
*.pininfo WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B
*.pininfo WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B
*.pininfo WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B
*.pininfo WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B
*.pininfo WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B
*.pininfo WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B
*.pininfo WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B
*.pininfo WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B
*.pininfo WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B
*.pininfo WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B
*.pininfo WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B
*.pininfo WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B
*.pininfo WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B
*.pininfo WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B
*.pininfo WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B
*.pininfo WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B
*.pininfo WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B
*.pininfo WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B
*.pininfo WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B
*.pininfo WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B
*.pininfo WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B
*.pininfo WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B
*.pininfo WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B
*.pininfo WL[253]:B WL[254]:B WL[255]:B RWL:B BB_TOP[0]:B BB_TOP[1]:B
*.pininfo BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B
*.pininfo BB_TOP[7]:B BB_TOP[8]:B BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B
*.pininfo BB_TOP[12]:B BB_TOP[13]:B BB_TOP[14]:B BB_TOP[15]:B
XXc0r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX bitcell_cap_cm16 m=1
XXc1r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[0] WL[1] WL[2] WL[3] bitcell_cm16 m=1
XXc2r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[4] WL[5] WL[6] WL[7] bitcell_cm16 m=1
XXc3r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[8] WL[9] WL[10] WL[11] bitcell_cm16 m=1
XXc4r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[12] WL[13] WL[14] WL[15] bitcell_cm16 m=1
XXc5r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[16] WL[17] WL[18] WL[19] bitcell_cm16 m=1
XXc6r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[20] WL[21] WL[22] WL[23] bitcell_cm16 m=1
XXc7r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[24] WL[25] WL[26] WL[27] bitcell_cm16 m=1
XXc8r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[28] WL[29] WL[30] WL[31] bitcell_cm16 m=1
XXc9r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[32] WL[33] WL[34] WL[35] bitcell_cm16 m=1
XXc10r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[36] WL[37] WL[38] WL[39] bitcell_cm16 m=1
XXc11r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[40] WL[41] WL[42] WL[43] bitcell_cm16 m=1
XXc12r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[44] WL[45] WL[46] WL[47] bitcell_cm16 m=1
XXc13r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[48] WL[49] WL[50] WL[51] bitcell_cm16 m=1
XXc14r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[52] WL[53] WL[54] WL[55] bitcell_cm16 m=1
XXc15r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[56] WL[57] WL[58] WL[59] bitcell_cm16 m=1
XXc16r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[60] WL[61] WL[62] WL[63] bitcell_cm16 m=1
XXc17r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[64] WL[65] WL[66] WL[67] bitcell_cm16 m=1
XXc18r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[68] WL[69] WL[70] WL[71] bitcell_cm16 m=1
XXc19r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[72] WL[73] WL[74] WL[75] bitcell_cm16 m=1
XXc20r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[76] WL[77] WL[78] WL[79] bitcell_cm16 m=1
XXc21r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[80] WL[81] WL[82] WL[83] bitcell_cm16 m=1
XXc22r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[84] WL[85] WL[86] WL[87] bitcell_cm16 m=1
XXc23r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[88] WL[89] WL[90] WL[91] bitcell_cm16 m=1
XXc24r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[92] WL[93] WL[94] WL[95] bitcell_cm16 m=1
XXc25r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[96] WL[97] WL[98] WL[99] bitcell_cm16 m=1
XXc26r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[100] WL[101] WL[102] WL[103] bitcell_cm16 m=1
XXc27r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[104] WL[105] WL[106] WL[107] bitcell_cm16 m=1
XXc28r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[108] WL[109] WL[110] WL[111] bitcell_cm16 m=1
XXc29r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[112] WL[113] WL[114] WL[115] bitcell_cm16 m=1
XXc30r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[116] WL[117] WL[118] WL[119] bitcell_cm16 m=1
XXc31r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[120] WL[121] WL[122] WL[123] bitcell_cm16 m=1
XXc32r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[124] WL[125] WL[126] WL[127] bitcell_cm16 m=1
XXc33r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[128] WL[129] WL[130] WL[131] bitcell_cm16 m=1
XXc34r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[132] WL[133] WL[134] WL[135] bitcell_cm16 m=1
XXc35r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[136] WL[137] WL[138] WL[139] bitcell_cm16 m=1
XXc36r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[140] WL[141] WL[142] WL[143] bitcell_cm16 m=1
XXc37r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[144] WL[145] WL[146] WL[147] bitcell_cm16 m=1
XXc38r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[148] WL[149] WL[150] WL[151] bitcell_cm16 m=1
XXc39r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[152] WL[153] WL[154] WL[155] bitcell_cm16 m=1
XXc40r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[156] WL[157] WL[158] WL[159] bitcell_cm16 m=1
XXc41r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[160] WL[161] WL[162] WL[163] bitcell_cm16 m=1
XXc42r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[164] WL[165] WL[166] WL[167] bitcell_cm16 m=1
XXc43r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[168] WL[169] WL[170] WL[171] bitcell_cm16 m=1
XXc44r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[172] WL[173] WL[174] WL[175] bitcell_cm16 m=1
XXc45r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[176] WL[177] WL[178] WL[179] bitcell_cm16 m=1
XXc46r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[180] WL[181] WL[182] WL[183] bitcell_cm16 m=1
XXc47r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[184] WL[185] WL[186] WL[187] bitcell_cm16 m=1
XXc48r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[188] WL[189] WL[190] WL[191] bitcell_cm16 m=1
XXc49r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[192] WL[193] WL[194] WL[195] bitcell_cm16 m=1
XXc50r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[196] WL[197] WL[198] WL[199] bitcell_cm16 m=1
XXc51r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[200] WL[201] WL[202] WL[203] bitcell_cm16 m=1
XXc52r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[204] WL[205] WL[206] WL[207] bitcell_cm16 m=1
XXc53r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[208] WL[209] WL[210] WL[211] bitcell_cm16 m=1
XXc54r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[212] WL[213] WL[214] WL[215] bitcell_cm16 m=1
XXc55r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[216] WL[217] WL[218] WL[219] bitcell_cm16 m=1
XXc56r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[220] WL[221] WL[222] WL[223] bitcell_cm16 m=1
XXc57r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[224] WL[225] WL[226] WL[227] bitcell_cm16 m=1
XXc58r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[228] WL[229] WL[230] WL[231] bitcell_cm16 m=1
XXc59r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[232] WL[233] WL[234] WL[235] bitcell_cm16 m=1
XXc60r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[236] WL[237] WL[238] WL[239] bitcell_cm16 m=1
XXc61r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[240] WL[241] WL[242] WL[243] bitcell_cm16 m=1
XXc62r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[244] WL[245] WL[246] WL[247] bitcell_cm16 m=1
XXc63r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[248] WL[249] WL[250] WL[251] bitcell_cm16 m=1
XXc64r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[252] WL[253] WL[254] WL[255] bitcell_cm16 m=1
XXc65r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3]
+ BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10]
+ BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] BT[0] BT[1] BT[2]
+ BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] PWR RWL VDDA VNW VSS VSSX local_tmr_wl_cm16 m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_TMR_SLICE GD[0]
+ GBW[0] VSSX GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] BB[0] BB[1]
+ BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+ BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] VNW VSS VDDA PWR WL[0] WL[1]
+ WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL
+ BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6]
+ BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13]
+ BB_TOP[14] BB_TOP[15]
*.pininfo GD[0]:B GBW[0]:B VSSX:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B
*.pininfo BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.pininfo BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.pininfo BT[15]:B VNW:B VSS:B VDDA:B PWR:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.pininfo WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B
*.pininfo WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B
*.pininfo WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B
*.pininfo WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B
*.pininfo WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B
*.pininfo WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B
*.pininfo WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B
*.pininfo WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B
*.pininfo WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B
*.pininfo WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B
*.pininfo WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B
*.pininfo WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B
*.pininfo WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B
*.pininfo WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B
*.pininfo WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B
*.pininfo WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B
*.pininfo WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B
*.pininfo WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B
*.pininfo WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B
*.pininfo WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B
*.pininfo WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B
*.pininfo WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B
*.pininfo WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B
*.pininfo WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B
*.pininfo WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B
*.pininfo WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B
*.pininfo WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B
*.pininfo WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B
*.pininfo WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B
*.pininfo WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B
*.pininfo WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B
*.pininfo WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B
*.pininfo WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B
*.pininfo WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B
*.pininfo WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B
*.pininfo WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B
*.pininfo WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B
*.pininfo WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B
*.pininfo WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B
*.pininfo WL[253]:B WL[254]:B WL[255]:B RWL:B BB_TOP[0]:B BB_TOP[1]:B
*.pininfo BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B
*.pininfo BB_TOP[7]:B BB_TOP[8]:B BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B
*.pininfo BB_TOP[12]:B BB_TOP[13]:B BB_TOP[14]:B BB_TOP[15]:B
XXc0r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX bitcell_cap_cm16 m=1
XXc1r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[0] WL[1] WL[2] WL[3] bitcell_cm16 m=1
XXc2r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[4] WL[5] WL[6] WL[7] bitcell_cm16 m=1
XXc3r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[8] WL[9] WL[10] WL[11] bitcell_cm16 m=1
XXc4r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[12] WL[13] WL[14] WL[15] bitcell_cm16 m=1
XXc5r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[16] WL[17] WL[18] WL[19] bitcell_cm16 m=1
XXc6r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[20] WL[21] WL[22] WL[23] bitcell_cm16 m=1
XXc7r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[24] WL[25] WL[26] WL[27] bitcell_cm16 m=1
XXc8r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[28] WL[29] WL[30] WL[31] bitcell_cm16 m=1
XXc9r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[32] WL[33] WL[34] WL[35] bitcell_cm16 m=1
XXc10r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[36] WL[37] WL[38] WL[39] bitcell_cm16 m=1
XXc11r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[40] WL[41] WL[42] WL[43] bitcell_cm16 m=1
XXc12r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[44] WL[45] WL[46] WL[47] bitcell_cm16 m=1
XXc13r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[48] WL[49] WL[50] WL[51] bitcell_cm16 m=1
XXc14r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[52] WL[53] WL[54] WL[55] bitcell_cm16 m=1
XXc15r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[56] WL[57] WL[58] WL[59] bitcell_cm16 m=1
XXc16r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[60] WL[61] WL[62] WL[63] bitcell_cm16 m=1
XXc17r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[64] WL[65] WL[66] WL[67] bitcell_cm16 m=1
XXc18r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[68] WL[69] WL[70] WL[71] bitcell_cm16 m=1
XXc19r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[72] WL[73] WL[74] WL[75] bitcell_cm16 m=1
XXc20r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[76] WL[77] WL[78] WL[79] bitcell_cm16 m=1
XXc21r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[80] WL[81] WL[82] WL[83] bitcell_cm16 m=1
XXc22r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[84] WL[85] WL[86] WL[87] bitcell_cm16 m=1
XXc23r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[88] WL[89] WL[90] WL[91] bitcell_cm16 m=1
XXc24r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[92] WL[93] WL[94] WL[95] bitcell_cm16 m=1
XXc25r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[96] WL[97] WL[98] WL[99] bitcell_cm16 m=1
XXc26r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[100] WL[101] WL[102] WL[103] bitcell_cm16 m=1
XXc27r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[104] WL[105] WL[106] WL[107] bitcell_cm16 m=1
XXc28r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[108] WL[109] WL[110] WL[111] bitcell_cm16 m=1
XXc29r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[112] WL[113] WL[114] WL[115] bitcell_cm16 m=1
XXc30r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[116] WL[117] WL[118] WL[119] bitcell_cm16 m=1
XXc31r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[120] WL[121] WL[122] WL[123] bitcell_cm16 m=1
XXc32r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[124] WL[125] WL[126] WL[127] bitcell_cm16 m=1
XXc33r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[128] WL[129] WL[130] WL[131] bitcell_cm16 m=1
XXc34r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[132] WL[133] WL[134] WL[135] bitcell_cm16 m=1
XXc35r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[136] WL[137] WL[138] WL[139] bitcell_cm16 m=1
XXc36r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[140] WL[141] WL[142] WL[143] bitcell_cm16 m=1
XXc37r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[144] WL[145] WL[146] WL[147] bitcell_cm16 m=1
XXc38r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[148] WL[149] WL[150] WL[151] bitcell_cm16 m=1
XXc39r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[152] WL[153] WL[154] WL[155] bitcell_cm16 m=1
XXc40r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[156] WL[157] WL[158] WL[159] bitcell_cm16 m=1
XXc41r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[160] WL[161] WL[162] WL[163] bitcell_cm16 m=1
XXc42r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[164] WL[165] WL[166] WL[167] bitcell_cm16 m=1
XXc43r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[168] WL[169] WL[170] WL[171] bitcell_cm16 m=1
XXc44r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[172] WL[173] WL[174] WL[175] bitcell_cm16 m=1
XXc45r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[176] WL[177] WL[178] WL[179] bitcell_cm16 m=1
XXc46r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[180] WL[181] WL[182] WL[183] bitcell_cm16 m=1
XXc47r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[184] WL[185] WL[186] WL[187] bitcell_cm16 m=1
XXc48r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[188] WL[189] WL[190] WL[191] bitcell_cm16 m=1
XXc49r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[192] WL[193] WL[194] WL[195] bitcell_cm16 m=1
XXc50r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[196] WL[197] WL[198] WL[199] bitcell_cm16 m=1
XXc51r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[200] WL[201] WL[202] WL[203] bitcell_cm16 m=1
XXc52r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[204] WL[205] WL[206] WL[207] bitcell_cm16 m=1
XXc53r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[208] WL[209] WL[210] WL[211] bitcell_cm16 m=1
XXc54r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[212] WL[213] WL[214] WL[215] bitcell_cm16 m=1
XXc55r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[216] WL[217] WL[218] WL[219] bitcell_cm16 m=1
XXc56r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[220] WL[221] WL[222] WL[223] bitcell_cm16 m=1
XXc57r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[224] WL[225] WL[226] WL[227] bitcell_cm16 m=1
XXc58r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[228] WL[229] WL[230] WL[231] bitcell_cm16 m=1
XXc59r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[232] WL[233] WL[234] WL[235] bitcell_cm16 m=1
XXc60r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[236] WL[237] WL[238] WL[239] bitcell_cm16 m=1
XXc61r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[240] WL[241] WL[242] WL[243] bitcell_cm16 m=1
XXc62r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[244] WL[245] WL[246] WL[247] bitcell_cm16 m=1
XXc63r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[248] WL[249] WL[250] WL[251] bitcell_cm16 m=1
XXc64r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[252] WL[253] WL[254] WL[255] bitcell_cm16 m=1
XXc65r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3]
+ BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10]
+ BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] BT[0] BT[1] BT[2]
+ BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] PWR RWL VDDA VNW VSS VSSX local_tmr_wl_cm16 m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_TMR_SLICE

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY GD[0] GBW[0] VSSX
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] BB[0] BB[1] BB[2]
+ BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+ BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] RWL BB_TOP[0] BB_TOP[1] BB_TOP[2]
+ BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9]
+ BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] WL[0]
+ WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+ WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+ WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+ WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+ WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+ WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+ WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72]
+ WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82]
+ WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92]
+ WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102]
+ WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111]
+ WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120]
+ WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129]
+ WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138]
+ WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147]
+ WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156]
+ WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165]
+ WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174]
+ WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183]
+ WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192]
+ WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201]
+ WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210]
+ WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219]
+ WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228]
+ WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237]
+ WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246]
+ WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW
+ VSS VDDA PWR GD[1] GBW[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+ BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18]
+ BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+ BT[29] BT[30] BT[31] BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20]
+ BB_TOP[21] BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26]
+ BB_TOP[27] BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] GD[2] GBW[2] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] BB[32] BB[33] BB[34]
+ BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44]
+ BB[45] BB[46] BB[47] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38]
+ BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BB_TOP[32]
+ BB_TOP[33] BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38]
+ BB_TOP[39] BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44]
+ BB_TOP[45] BB_TOP[46] BB_TOP[47] GD[3] GBW[3] GRD0[12] GRD0[13] GRD0[14]
+ GRD0[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD3[12] GRD3[13] GRD3[14] GRD3[15] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+ BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BB_TOP[48]
+ BB_TOP[49] BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54]
+ BB_TOP[55] BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60]
+ BB_TOP[61] BB_TOP[62] BB_TOP[63] GD[4] GBW[4] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19] BB[64] BB[65] BB[66] BB[67]
+ BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77]
+ BB[78] BB[79] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71]
+ BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BB_TOP[64]
+ BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69] BB_TOP[70]
+ BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75] BB_TOP[76]
+ BB_TOP[77] BB_TOP[78] BB_TOP[79] GD[5] GBW[5] GRD0[20] GRD0[21] GRD0[22]
+ GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] BB[80] BB[81] BB[82] BB[83]
+ BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+ BB[94] BB[95] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87]
+ BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BB_TOP[80]
+ BB_TOP[81] BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86]
+ BB_TOP[87] BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92]
+ BB_TOP[93] BB_TOP[94] BB_TOP[95] GD[6] GBW[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] BB[96] BB[97] BB[98] BB[99]
+ BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+ BB[109] BB[110] BB[111] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102]
+ BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111]
+ BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101]
+ BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107]
+ BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111] GD[7] GBW[7] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29] GRD3[30] GRD3[31] BB[112]
+ BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+ BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[112] BT[113] BT[114]
+ BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+ BT[124] BT[125] BT[126] BT[127] BB_TOP[112] BB_TOP[113] BB_TOP[114]
+ BB_TOP[115] BB_TOP[116] BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120]
+ BB_TOP[121] BB_TOP[122] BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126]
+ BB_TOP[127]
*.pininfo GD[0]:B GBW[0]:B VSSX:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B
*.pininfo BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.pininfo BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.pininfo BT[15]:B RWL:B BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B
*.pininfo BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BB_TOP[8]:B
*.pininfo BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B BB_TOP[12]:B BB_TOP[13]:B
*.pininfo BB_TOP[14]:B BB_TOP[15]:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B
*.pininfo WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B
*.pininfo WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B
*.pininfo WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B
*.pininfo WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B
*.pininfo WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B
*.pininfo WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B
*.pininfo WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B
*.pininfo WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B
*.pininfo WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B
*.pininfo WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B
*.pininfo WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B
*.pininfo WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B
*.pininfo WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B
*.pininfo WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B
*.pininfo WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B
*.pininfo WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B
*.pininfo WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B
*.pininfo WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B
*.pininfo WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B
*.pininfo WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B
*.pininfo WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B
*.pininfo WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B
*.pininfo WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B
*.pininfo WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B
*.pininfo WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B
*.pininfo WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B
*.pininfo WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B
*.pininfo WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B
*.pininfo WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B
*.pininfo WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B
*.pininfo WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B
*.pininfo WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B
*.pininfo WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B
*.pininfo WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B
*.pininfo WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B
*.pininfo WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B
*.pininfo WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B
*.pininfo WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B
*.pininfo WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B
*.pininfo WL[254]:B WL[255]:B VNW:B VSS:B VDDA:B PWR:B GD[1]:B GBW[1]:B
*.pininfo GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD1[4]:B GRD1[5]:B
*.pininfo GRD1[6]:B GRD1[7]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B
*.pininfo GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B BB[16]:B BB[17]:B BB[18]:B
*.pininfo BB[19]:B BB[20]:B BB[21]:B BB[22]:B BB[23]:B BB[24]:B BB[25]:B
*.pininfo BB[26]:B BB[27]:B BB[28]:B BB[29]:B BB[30]:B BB[31]:B BT[16]:B
*.pininfo BT[17]:B BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B BT[23]:B
*.pininfo BT[24]:B BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B BT[30]:B
*.pininfo BT[31]:B BB_TOP[16]:B BB_TOP[17]:B BB_TOP[18]:B BB_TOP[19]:B
*.pininfo BB_TOP[20]:B BB_TOP[21]:B BB_TOP[22]:B BB_TOP[23]:B BB_TOP[24]:B
*.pininfo BB_TOP[25]:B BB_TOP[26]:B BB_TOP[27]:B BB_TOP[28]:B BB_TOP[29]:B
*.pininfo BB_TOP[30]:B BB_TOP[31]:B GD[2]:B GBW[2]:B GRD0[8]:B GRD0[9]:B
*.pininfo GRD0[10]:B GRD0[11]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B
*.pininfo GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD3[8]:B GRD3[9]:B
*.pininfo GRD3[10]:B GRD3[11]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B BB[36]:B
*.pininfo BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B BB[43]:B
*.pininfo BB[44]:B BB[45]:B BB[46]:B BB[47]:B BT[32]:B BT[33]:B BT[34]:B
*.pininfo BT[35]:B BT[36]:B BT[37]:B BT[38]:B BT[39]:B BT[40]:B BT[41]:B
*.pininfo BT[42]:B BT[43]:B BT[44]:B BT[45]:B BT[46]:B BT[47]:B BB_TOP[32]:B
*.pininfo BB_TOP[33]:B BB_TOP[34]:B BB_TOP[35]:B BB_TOP[36]:B BB_TOP[37]:B
*.pininfo BB_TOP[38]:B BB_TOP[39]:B BB_TOP[40]:B BB_TOP[41]:B BB_TOP[42]:B
*.pininfo BB_TOP[43]:B BB_TOP[44]:B BB_TOP[45]:B BB_TOP[46]:B BB_TOP[47]:B
*.pininfo GD[3]:B GBW[3]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B
*.pininfo GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B
*.pininfo BB[48]:B BB[49]:B BB[50]:B BB[51]:B BB[52]:B BB[53]:B BB[54]:B
*.pininfo BB[55]:B BB[56]:B BB[57]:B BB[58]:B BB[59]:B BB[60]:B BB[61]:B
*.pininfo BB[62]:B BB[63]:B BT[48]:B BT[49]:B BT[50]:B BT[51]:B BT[52]:B
*.pininfo BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B BT[58]:B BT[59]:B
*.pininfo BT[60]:B BT[61]:B BT[62]:B BT[63]:B BB_TOP[48]:B BB_TOP[49]:B
*.pininfo BB_TOP[50]:B BB_TOP[51]:B BB_TOP[52]:B BB_TOP[53]:B BB_TOP[54]:B
*.pininfo BB_TOP[55]:B BB_TOP[56]:B BB_TOP[57]:B BB_TOP[58]:B BB_TOP[59]:B
*.pininfo BB_TOP[60]:B BB_TOP[61]:B BB_TOP[62]:B BB_TOP[63]:B GD[4]:B
*.pininfo GBW[4]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B BB[64]:B
*.pininfo BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B BB[71]:B
*.pininfo BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B BB[78]:B
*.pininfo BB[79]:B BT[64]:B BT[65]:B BT[66]:B BT[67]:B BT[68]:B BT[69]:B
*.pininfo BT[70]:B BT[71]:B BT[72]:B BT[73]:B BT[74]:B BT[75]:B BT[76]:B
*.pininfo BT[77]:B BT[78]:B BT[79]:B BB_TOP[64]:B BB_TOP[65]:B BB_TOP[66]:B
*.pininfo BB_TOP[67]:B BB_TOP[68]:B BB_TOP[69]:B BB_TOP[70]:B BB_TOP[71]:B
*.pininfo BB_TOP[72]:B BB_TOP[73]:B BB_TOP[74]:B BB_TOP[75]:B BB_TOP[76]:B
*.pininfo BB_TOP[77]:B BB_TOP[78]:B BB_TOP[79]:B GD[5]:B GBW[5]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B BB[80]:B BB[81]:B BB[82]:B
*.pininfo BB[83]:B BB[84]:B BB[85]:B BB[86]:B BB[87]:B BB[88]:B BB[89]:B
*.pininfo BB[90]:B BB[91]:B BB[92]:B BB[93]:B BB[94]:B BB[95]:B BT[80]:B
*.pininfo BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B BT[86]:B BT[87]:B
*.pininfo BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B BT[93]:B BT[94]:B
*.pininfo BT[95]:B BB_TOP[80]:B BB_TOP[81]:B BB_TOP[82]:B BB_TOP[83]:B
*.pininfo BB_TOP[84]:B BB_TOP[85]:B BB_TOP[86]:B BB_TOP[87]:B BB_TOP[88]:B
*.pininfo BB_TOP[89]:B BB_TOP[90]:B BB_TOP[91]:B BB_TOP[92]:B BB_TOP[93]:B
*.pininfo BB_TOP[94]:B BB_TOP[95]:B GD[6]:B GBW[6]:B GRD0[24]:B GRD0[25]:B
*.pininfo GRD0[26]:B GRD0[27]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B
*.pininfo GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD3[24]:B GRD3[25]:B
*.pininfo GRD3[26]:B GRD3[27]:B BB[96]:B BB[97]:B BB[98]:B BB[99]:B BB[100]:B
*.pininfo BB[101]:B BB[102]:B BB[103]:B BB[104]:B BB[105]:B BB[106]:B
*.pininfo BB[107]:B BB[108]:B BB[109]:B BB[110]:B BB[111]:B BT[96]:B BT[97]:B
*.pininfo BT[98]:B BT[99]:B BT[100]:B BT[101]:B BT[102]:B BT[103]:B BT[104]:B
*.pininfo BT[105]:B BT[106]:B BT[107]:B BT[108]:B BT[109]:B BT[110]:B
*.pininfo BT[111]:B BB_TOP[96]:B BB_TOP[97]:B BB_TOP[98]:B BB_TOP[99]:B
*.pininfo BB_TOP[100]:B BB_TOP[101]:B BB_TOP[102]:B BB_TOP[103]:B
*.pininfo BB_TOP[104]:B BB_TOP[105]:B BB_TOP[106]:B BB_TOP[107]:B
*.pininfo BB_TOP[108]:B BB_TOP[109]:B BB_TOP[110]:B BB_TOP[111]:B GD[7]:B
*.pininfo GBW[7]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B
*.pininfo GRD2[31]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B BB[112]:B
*.pininfo BB[113]:B BB[114]:B BB[115]:B BB[116]:B BB[117]:B BB[118]:B
*.pininfo BB[119]:B BB[120]:B BB[121]:B BB[122]:B BB[123]:B BB[124]:B
*.pininfo BB[125]:B BB[126]:B BB[127]:B BT[112]:B BT[113]:B BT[114]:B
*.pininfo BT[115]:B BT[116]:B BT[117]:B BT[118]:B BT[119]:B BT[120]:B
*.pininfo BT[121]:B BT[122]:B BT[123]:B BT[124]:B BT[125]:B BT[126]:B
*.pininfo BT[127]:B BB_TOP[112]:B BB_TOP[113]:B BB_TOP[114]:B BB_TOP[115]:B
*.pininfo BB_TOP[116]:B BB_TOP[117]:B BB_TOP[118]:B BB_TOP[119]:B
*.pininfo BB_TOP[120]:B BB_TOP[121]:B BB_TOP[122]:B BB_TOP[123]:B
*.pininfo BB_TOP[124]:B BB_TOP[125]:B BB_TOP[126]:B BB_TOP[127]:B
XX00 GD[0] GBW[0] VSSX GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] VNW VSS
+ VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10]
+ WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+ WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30]
+ WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40]
+ WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50]
+ WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+ WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70]
+ WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80]
+ WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90]
+ WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100]
+ WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109]
+ WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118]
+ WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127]
+ WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136]
+ WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145]
+ WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154]
+ WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163]
+ WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172]
+ WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181]
+ WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190]
+ WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199]
+ WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208]
+ WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217]
+ WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226]
+ WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235]
+ WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244]
+ WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253]
+ WL[254] WL[255] RWL BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4]
+ BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11]
+ BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE m=1
XX01 GD[1] GBW[1] VSSX GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+ BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18]
+ BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+ BT[29] BT[30] BT[31] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5]
+ WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16]
+ WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26]
+ WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36]
+ WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46]
+ WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56]
+ WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66]
+ WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76]
+ WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86]
+ WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96]
+ WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[16] BB_TOP[17]
+ BB_TOP[18] BB_TOP[19] BB_TOP[20] BB_TOP[21] BB_TOP[22] BB_TOP[23]
+ BB_TOP[24] BB_TOP[25] BB_TOP[26] BB_TOP[27] BB_TOP[28] BB_TOP[29]
+ BB_TOP[30] BB_TOP[31]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE m=1
XX02 GD[2] GBW[2] VSSX GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9]
+ GRD1[10] GRD1[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD3[8] GRD3[9]
+ GRD3[10] GRD3[11] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39]
+ BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BT[32] BT[33]
+ BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+ BT[44] BT[45] BT[46] BT[47] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[32] BB_TOP[33]
+ BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38] BB_TOP[39]
+ BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44] BB_TOP[45]
+ BB_TOP[46] BB_TOP[47]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE m=1
XX03 GD[3] GBW[3] VSSX GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD3[12] GRD3[13]
+ GRD3[14] GRD3[15] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55]
+ BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[48] BT[49]
+ BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+ BT[60] BT[61] BT[62] BT[63] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[48] BB_TOP[49]
+ BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55]
+ BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61]
+ BB_TOP[62] BB_TOP[63]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE m=1
XX04 GD[4] GBW[4] VSSX GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD1[16] GRD1[17]
+ GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD3[16] GRD3[17]
+ GRD3[18] GRD3[19] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+ BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BT[64] BT[65]
+ BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75]
+ BT[76] BT[77] BT[78] BT[79] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[64] BB_TOP[65]
+ BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69] BB_TOP[70] BB_TOP[71]
+ BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75] BB_TOP[76] BB_TOP[77]
+ BB_TOP[78] BB_TOP[79]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE m=1
XX05 GD[5] GBW[5] VSSX GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD3[20] GRD3[21]
+ GRD3[22] GRD3[23] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87]
+ BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BT[80] BT[81]
+ BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91]
+ BT[92] BT[93] BT[94] BT[95] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[80] BB_TOP[81]
+ BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86] BB_TOP[87]
+ BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92] BB_TOP[93]
+ BB_TOP[94] BB_TOP[95]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE m=1
XX06 GD[6] GBW[6] VSSX GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD1[24] GRD1[25]
+ GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD3[24] GRD3[25]
+ GRD3[26] GRD3[27] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102]
+ BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111]
+ BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+ BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] VNW VSS VDDA PWR WL[0]
+ WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+ WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+ WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+ WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+ WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+ WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+ WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72]
+ WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82]
+ WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92]
+ WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102]
+ WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111]
+ WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120]
+ WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129]
+ WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138]
+ WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147]
+ WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156]
+ WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165]
+ WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174]
+ WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183]
+ WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192]
+ WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201]
+ WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210]
+ WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219]
+ WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228]
+ WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237]
+ WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246]
+ WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL
+ BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101]
+ BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107]
+ BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_SLICE m=1
XX07 GD[7] GBW[7] VSSX GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118]
+ BB[119] BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127]
+ BT[112] BT[113] BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120]
+ BT[121] BT[122] BT[123] BT[124] BT[125] BT[126] BT[127] VNW VSS VDDA PWR
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] RWL BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115] BB_TOP[116]
+ BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121] BB_TOP[122]
+ BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_TMR_SLICE m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BC_LD DBL VDDA VSSX VSS
+ VNW PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10]
+ WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+ WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30]
+ WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40]
+ WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50]
+ WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+ WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70]
+ WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80]
+ WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90]
+ WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100]
+ WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109]
+ WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118]
+ WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127]
+ WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136]
+ WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145]
+ WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154]
+ WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163]
+ WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172]
+ WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181]
+ WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190]
+ WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199]
+ WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208]
+ WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217]
+ WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226]
+ WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235]
+ WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244]
+ WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253]
+ WL[254] WL[255] RWL PD[0] PD[1] PD[2] PD[3]
*.pininfo DBL:B VDDA:B VSSX:B VSS:B VNW:B PWR:B WL[0]:B WL[1]:B WL[2]:B
*.pininfo WL[3]:B WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B
*.pininfo WL[11]:B WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B
*.pininfo WL[18]:B WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B
*.pininfo WL[25]:B WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B
*.pininfo WL[32]:B WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B
*.pininfo WL[39]:B WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B
*.pininfo WL[46]:B WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B
*.pininfo WL[53]:B WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B
*.pininfo WL[60]:B WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B
*.pininfo WL[67]:B WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B
*.pininfo WL[74]:B WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B
*.pininfo WL[81]:B WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B
*.pininfo WL[88]:B WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B
*.pininfo WL[95]:B WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B
*.pininfo WL[102]:B WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B
*.pininfo WL[108]:B WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B
*.pininfo WL[114]:B WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B
*.pininfo WL[120]:B WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B
*.pininfo WL[126]:B WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B
*.pininfo WL[132]:B WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B
*.pininfo WL[138]:B WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B
*.pininfo WL[144]:B WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B
*.pininfo WL[150]:B WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B
*.pininfo WL[156]:B WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B
*.pininfo WL[162]:B WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B
*.pininfo WL[168]:B WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B
*.pininfo WL[174]:B WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B
*.pininfo WL[180]:B WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B
*.pininfo WL[186]:B WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B
*.pininfo WL[192]:B WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B
*.pininfo WL[198]:B WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B
*.pininfo WL[204]:B WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B
*.pininfo WL[210]:B WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B
*.pininfo WL[216]:B WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B
*.pininfo WL[222]:B WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B
*.pininfo WL[228]:B WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B
*.pininfo WL[234]:B WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B
*.pininfo WL[240]:B WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B
*.pininfo WL[246]:B WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B
*.pininfo WL[252]:B WL[253]:B WL[254]:B WL[255]:B RWL:B PD[0]:B PD[1]:B
*.pininfo PD[2]:B PD[3]:B
XXc0r0 DBL PWR SETDBLB VDDA VNW VSS VSSX bitcell_edge_tmr_cap m=1
XXc1r0 DBL DEVBLT_BOT DEVBLT_TOP PWR SETDBLB VDDA VNW VSS VSSX WL[0] WL[1]
+ WL[2] WL[3] bitcell_edge_tmr m=1
XXc2r0 DBL DEVBLT_TOP DEVBLT_TOP_0 PWR SETDBLB VDDA VNW VSS VSSX WL[4] WL[5]
+ WL[6] WL[7] bitcell_edge_tmr m=1
XXc3r0 DBL DEVBLT_TOP_0 DEVBLT_TOP_1 PWR SETDBLB VDDA VNW VSS VSSX WL[8]
+ WL[9] WL[10] WL[11] bitcell_edge_tmr m=1
XXc4r0 DBL DEVBLT_TOP_1 DEVBLT_TOP_2 PWR SETDBLB VDDA VNW VSS VSSX WL[12]
+ WL[13] WL[14] WL[15] bitcell_edge_tmr m=1
XXc5r0 DBL DEVBLT_TOP_2 DEVBLT_TOP_3 PWR SETDBLB VDDA VNW VSS VSSX WL[16]
+ WL[17] WL[18] WL[19] bitcell_edge_tmr m=1
XXc6r0 DBL DEVBLT_TOP_3 DEVBLT_TOP_4 PWR SETDBLB VDDA VNW VSS VSSX WL[20]
+ WL[21] WL[22] WL[23] bitcell_edge_tmr m=1
XXc7r0 DBL DEVBLT_TOP_4 DEVBLT_TOP_5 PWR SETDBLB VDDA VNW VSS VSSX WL[24]
+ WL[25] WL[26] WL[27] bitcell_edge_tmr m=1
XXc8r0 DBL DEVBLT_TOP_5 DEVBLT_TOP_6 PWR SETDBLB VDDA VNW VSS VSSX WL[28]
+ WL[29] WL[30] WL[31] bitcell_edge_tmr m=1
XXc9r0 DBL DEVBLT_TOP_6 DEVBLT_TOP_7 PWR SETDBLB VDDA VNW VSS VSSX WL[32]
+ WL[33] WL[34] WL[35] bitcell_edge_tmr m=1
XXc10r0 DBL DEVBLT_TOP_7 DEVBLT_TOP_8 PWR SETDBLB VDDA VNW VSS VSSX WL[36]
+ WL[37] WL[38] WL[39] bitcell_edge_tmr m=1
XXc11r0 DBL DEVBLT_TOP_8 DEVBLT_TOP_9 PWR SETDBLB VDDA VNW VSS VSSX WL[40]
+ WL[41] WL[42] WL[43] bitcell_edge_tmr m=1
XXc12r0 DBL DEVBLT_TOP_9 DEVBLT_TOP_10 PWR SETDBLB VDDA VNW VSS VSSX WL[44]
+ WL[45] WL[46] WL[47] bitcell_edge_tmr m=1
XXc13r0 DBL DEVBLT_TOP_10 DEVBLT_TOP_11 PWR SETDBLB VDDA VNW VSS VSSX WL[48]
+ WL[49] WL[50] WL[51] bitcell_edge_tmr m=1
XXc14r0 DBL DEVBLT_TOP_11 DEVBLT_TOP_12 PWR SETDBLB VDDA VNW VSS VSSX WL[52]
+ WL[53] WL[54] WL[55] bitcell_edge_tmr m=1
XXc15r0 DBL DEVBLT_TOP_12 DEVBLT_TOP_13 PWR SETDBLB VDDA VNW VSS VSSX WL[56]
+ WL[57] WL[58] WL[59] bitcell_edge_tmr m=1
XXc16r0 DBL DEVBLT_TOP_13 DEVBLT_TOP_14 PWR SETDBLB VDDA VNW VSS VSSX WL[60]
+ WL[61] WL[62] WL[63] bitcell_edge_tmr m=1
XXc17r0 DBL DEVBLT_TOP_14 DEVBLT_TOP_15 PWR SETDBLB VDDA VNW VSS VSSX WL[64]
+ WL[65] WL[66] WL[67] bitcell_edge_tmr m=1
XXc18r0 DBL DEVBLT_TOP_15 DEVBLT_TOP_16 PWR SETDBLB VDDA VNW VSS VSSX WL[68]
+ WL[69] WL[70] WL[71] bitcell_edge_tmr m=1
XXc19r0 DBL DEVBLT_TOP_16 DEVBLT_TOP_17 PWR SETDBLB VDDA VNW VSS VSSX WL[72]
+ WL[73] WL[74] WL[75] bitcell_edge_tmr m=1
XXc20r0 DBL DEVBLT_TOP_17 DEVBLT_TOP_18 PWR SETDBLB VDDA VNW VSS VSSX WL[76]
+ WL[77] WL[78] WL[79] bitcell_edge_tmr m=1
XXc21r0 DBL DEVBLT_TOP_18 DEVBLT_TOP_19 PWR SETDBLB VDDA VNW VSS VSSX WL[80]
+ WL[81] WL[82] WL[83] bitcell_edge_tmr m=1
XXc22r0 DBL DEVBLT_TOP_19 DEVBLT_TOP_20 PWR SETDBLB VDDA VNW VSS VSSX WL[84]
+ WL[85] WL[86] WL[87] bitcell_edge_tmr m=1
XXc23r0 DBL DEVBLT_TOP_20 DEVBLT_TOP_21 PWR SETDBLB VDDA VNW VSS VSSX WL[88]
+ WL[89] WL[90] WL[91] bitcell_edge_tmr m=1
XXc24r0 DBL DEVBLT_TOP_21 DEVBLT_TOP_22 PWR SETDBLB VDDA VNW VSS VSSX WL[92]
+ WL[93] WL[94] WL[95] bitcell_edge_tmr m=1
XXc25r0 DBL DEVBLT_TOP_22 DEVBLT_TOP_23 PWR SETDBLB VDDA VNW VSS VSSX WL[96]
+ WL[97] WL[98] WL[99] bitcell_edge_tmr m=1
XXc26r0 DBL DEVBLT_TOP_23 DEVBLT_TOP_24 PWR SETDBLB VDDA VNW VSS VSSX WL[100]
+ WL[101] WL[102] WL[103] bitcell_edge_tmr m=1
XXc27r0 DBL DEVBLT_TOP_24 DEVBLT_TOP_25 PWR SETDBLB VDDA VNW VSS VSSX WL[104]
+ WL[105] WL[106] WL[107] bitcell_edge_tmr m=1
XXc28r0 DBL DEVBLT_TOP_25 DEVBLT_TOP_26 PWR SETDBLB VDDA VNW VSS VSSX WL[108]
+ WL[109] WL[110] WL[111] bitcell_edge_tmr m=1
XXc29r0 DBL DEVBLT_TOP_26 DEVBLT_TOP_27 PWR SETDBLB VDDA VNW VSS VSSX WL[112]
+ WL[113] WL[114] WL[115] bitcell_edge_tmr m=1
XXc30r0 DBL DEVBLT_TOP_27 DEVBLT_TOP_28 PWR SETDBLB VDDA VNW VSS VSSX WL[116]
+ WL[117] WL[118] WL[119] bitcell_edge_tmr m=1
XXc31r0 DBL DEVBLT_TOP_28 DEVBLT_TOP_29 PWR SETDBLB VDDA VNW VSS VSSX WL[120]
+ WL[121] WL[122] WL[123] bitcell_edge_tmr m=1
XXc32r0 DBL DEVBLT_TOP_29 DEVBLT_TOP_30 PWR SETDBLB VDDA VNW VSS VSSX WL[124]
+ WL[125] WL[126] WL[127] bitcell_edge_tmr m=1
XXc33r0 DBL DEVBLT_TOP_30 DEVBLT_TOP_31 PWR SETDBLB VDDA VNW VSS VSSX WL[128]
+ WL[129] WL[130] WL[131] bitcell_edge_tmr m=1
XXc34r0 DBL DEVBLT_TOP_31 DEVBLT_TOP_32 PWR SETDBLB VDDA VNW VSS VSSX WL[132]
+ WL[133] WL[134] WL[135] bitcell_edge_tmr m=1
XXc35r0 DBL DEVBLT_TOP_32 DEVBLT_TOP_33 PWR SETDBLB VDDA VNW VSS VSSX WL[136]
+ WL[137] WL[138] WL[139] bitcell_edge_tmr m=1
XXc36r0 DBL DEVBLT_TOP_33 DEVBLT_TOP_34 PWR SETDBLB VDDA VNW VSS VSSX WL[140]
+ WL[141] WL[142] WL[143] bitcell_edge_tmr m=1
XXc37r0 DBL DEVBLT_TOP_34 DEVBLT_TOP_35 PWR SETDBLB VDDA VNW VSS VSSX WL[144]
+ WL[145] WL[146] WL[147] bitcell_edge_tmr m=1
XXc38r0 DBL DEVBLT_TOP_35 DEVBLT_TOP_36 PWR SETDBLB VDDA VNW VSS VSSX WL[148]
+ WL[149] WL[150] WL[151] bitcell_edge_tmr m=1
XXc39r0 DBL DEVBLT_TOP_36 DEVBLT_TOP_37 PWR SETDBLB VDDA VNW VSS VSSX WL[152]
+ WL[153] WL[154] WL[155] bitcell_edge_tmr m=1
XXc40r0 DBL DEVBLT_TOP_37 DEVBLT_TOP_38 PWR SETDBLB VDDA VNW VSS VSSX WL[156]
+ WL[157] WL[158] WL[159] bitcell_edge_tmr m=1
XXc41r0 DBL DEVBLT_TOP_38 DEVBLT_TOP_39 PWR SETDBLB VDDA VNW VSS VSSX WL[160]
+ WL[161] WL[162] WL[163] bitcell_edge_tmr m=1
XXc42r0 DBL DEVBLT_TOP_39 DEVBLT_TOP_40 PWR SETDBLB VDDA VNW VSS VSSX WL[164]
+ WL[165] WL[166] WL[167] bitcell_edge_tmr m=1
XXc43r0 DBL DEVBLT_TOP_40 DEVBLT_TOP_41 PWR SETDBLB VDDA VNW VSS VSSX WL[168]
+ WL[169] WL[170] WL[171] bitcell_edge_tmr m=1
XXc44r0 DBL DEVBLT_TOP_41 DEVBLT_TOP_42 PWR SETDBLB VDDA VNW VSS VSSX WL[172]
+ WL[173] WL[174] WL[175] bitcell_edge_tmr m=1
XXc45r0 DBL DEVBLT_TOP_42 DEVBLT_TOP_43 PWR SETDBLB VDDA VNW VSS VSSX WL[176]
+ WL[177] WL[178] WL[179] bitcell_edge_tmr m=1
XXc46r0 DBL DEVBLT_TOP_43 DEVBLT_TOP_44 PWR SETDBLB VDDA VNW VSS VSSX WL[180]
+ WL[181] WL[182] WL[183] bitcell_edge_tmr m=1
XXc47r0 DBL DEVBLT_TOP_44 DEVBLT_TOP_45 PWR SETDBLB VDDA VNW VSS VSSX WL[184]
+ WL[185] WL[186] WL[187] bitcell_edge_tmr m=1
XXc48r0 DBL DEVBLT_TOP_45 DEVBLT_TOP_46 PWR SETDBLB VDDA VNW VSS VSSX WL[188]
+ WL[189] WL[190] WL[191] bitcell_edge_tmr m=1
XXc49r0 DBL DEVBLT_TOP_46 DEVBLT_TOP_47 PWR SETDBLB VDDA VNW VSS VSSX WL[192]
+ WL[193] WL[194] WL[195] bitcell_edge_tmr m=1
XXc50r0 DBL DEVBLT_TOP_47 DEVBLT_TOP_48 PWR SETDBLB VDDA VNW VSS VSSX WL[196]
+ WL[197] WL[198] WL[199] bitcell_edge_tmr m=1
XXc51r0 DBL DEVBLT_TOP_48 DEVBLT_TOP_49 PWR SETDBLB VDDA VNW VSS VSSX WL[200]
+ WL[201] WL[202] WL[203] bitcell_edge_tmr m=1
XXc52r0 DBL DEVBLT_TOP_49 DEVBLT_TOP_50 PWR SETDBLB VDDA VNW VSS VSSX WL[204]
+ WL[205] WL[206] WL[207] bitcell_edge_tmr m=1
XXc53r0 DBL DEVBLT_TOP_50 DEVBLT_TOP_51 PWR SETDBLB VDDA VNW VSS VSSX WL[208]
+ WL[209] WL[210] WL[211] bitcell_edge_tmr m=1
XXc54r0 DBL DEVBLT_TOP_51 DEVBLT_TOP_52 PWR SETDBLB VDDA VNW VSS VSSX WL[212]
+ WL[213] WL[214] WL[215] bitcell_edge_tmr m=1
XXc55r0 DBL DEVBLT_TOP_52 DEVBLT_TOP_53 PWR SETDBLB VDDA VNW VSS VSSX WL[216]
+ WL[217] WL[218] WL[219] bitcell_edge_tmr m=1
XXc56r0 DBL DEVBLT_TOP_53 DEVBLT_TOP_54 PWR SETDBLB VDDA VNW VSS VSSX WL[220]
+ WL[221] WL[222] WL[223] bitcell_edge_tmr m=1
XXc57r0 DBL DEVBLT_TOP_54 DEVBLT_TOP_55 PWR SETDBLB VDDA VNW VSS VSSX WL[224]
+ WL[225] WL[226] WL[227] bitcell_edge_tmr m=1
XXc58r0 DBL DEVBLT_TOP_55 DEVBLT_TOP_56 PWR SETDBLB VDDA VNW VSS VSSX WL[228]
+ WL[229] WL[230] WL[231] bitcell_edge_tmr m=1
XXc59r0 DBL DEVBLT_TOP_56 DEVBLT_TOP_57 PWR SETDBLB VDDA VNW VSS VSSX WL[232]
+ WL[233] WL[234] WL[235] bitcell_edge_tmr m=1
XXc60r0 DBL DEVBLT_TOP_57 DEVBLT_TOP_58 PWR SETDBLB VDDA VNW VSS VSSX WL[236]
+ WL[237] WL[238] WL[239] bitcell_edge_tmr m=1
XXc61r0 DBL DEVBLT_TOP_58 DEVBLT_TOP_59 PWR SETDBLB VDDA VNW VSS VSSX WL[240]
+ WL[241] WL[242] WL[243] bitcell_edge_tmr m=1
XXc62r0 DBL DEVBLT_TOP_59 DEVBLT_TOP_60 PWR SETDBLB VDDA VNW VSS VSSX WL[244]
+ WL[245] WL[246] WL[247] bitcell_edge_tmr m=1
XXc63r0 DBL DEVBLT_TOP_60 DEVBLT_TOP_61 PWR SETDBLB VDDA VNW VSS VSSX WL[248]
+ WL[249] WL[250] WL[251] bitcell_edge_tmr m=1
XXc64r0 DBL DEVBLT_TOP_61 DEVBLT_TOP_62 PWR SETDBLB VDDA VNW VSS VSSX WL[252]
+ WL[253] WL[254] WL[255] bitcell_edge_tmr m=1
XXc65r0 DBL PWR RWL VDDA VNW VSS VSSX PD[0] PD[1] PD[2] PD[3]
+ bitcell_edge_coltmr_wl m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BC_LD

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGEL DBL VDDA VSSX VSS
+ RWL WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10]
+ WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+ WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30]
+ WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40]
+ WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50]
+ WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+ WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70]
+ WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80]
+ WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90]
+ WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100]
+ WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109]
+ WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118]
+ WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127]
+ WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136]
+ WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145]
+ WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154]
+ WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163]
+ WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172]
+ WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181]
+ WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190]
+ WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199]
+ WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208]
+ WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217]
+ WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226]
+ WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235]
+ WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244]
+ WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253]
+ WL[254] WL[255] VNW PWR PD[0] PD[1] PD[2] PD[3]
*.pininfo DBL:B VDDA:B VSSX:B VSS:B RWL:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.pininfo WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B
*.pininfo WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B
*.pininfo WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B
*.pininfo WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B
*.pininfo WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B
*.pininfo WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B
*.pininfo WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B
*.pininfo WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B
*.pininfo WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B
*.pininfo WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B
*.pininfo WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B
*.pininfo WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B
*.pininfo WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B
*.pininfo WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B
*.pininfo WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B
*.pininfo WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B
*.pininfo WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B
*.pininfo WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B
*.pininfo WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B
*.pininfo WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B
*.pininfo WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B
*.pininfo WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B
*.pininfo WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B
*.pininfo WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B
*.pininfo WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B
*.pininfo WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B
*.pininfo WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B
*.pininfo WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B
*.pininfo WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B
*.pininfo WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B
*.pininfo WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B
*.pininfo WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B
*.pininfo WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B
*.pininfo WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B
*.pininfo WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B
*.pininfo WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B
*.pininfo WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B
*.pininfo WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B
*.pininfo WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B
*.pininfo WL[253]:B WL[254]:B WL[255]:B VNW:B PWR:B PD[0]:B PD[1]:B PD[2]:B
*.pininfo PD[3]:B
XX10 DBL VDDA VSSX VSS VNW PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6]
+ WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17]
+ WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27]
+ WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37]
+ WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47]
+ WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57]
+ WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67]
+ WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77]
+ WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87]
+ WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97]
+ WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105] WL[106]
+ WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114] WL[115]
+ WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123] WL[124]
+ WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132] WL[133]
+ WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141] WL[142]
+ WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150] WL[151]
+ WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159] WL[160]
+ WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168] WL[169]
+ WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177] WL[178]
+ WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186] WL[187]
+ WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195] WL[196]
+ WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204] WL[205]
+ WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213] WL[214]
+ WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222] WL[223]
+ WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231] WL[232]
+ WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240] WL[241]
+ WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249] WL[250]
+ WL[251] WL[252] WL[253] WL[254] WL[255] RWL PD[0] PD[1] PD[2] PD[3]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BC_LD m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGEL

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA VDDA VSS WL[0] WL[1] WL[2]
+ WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW PWR
+ VSSX RWL GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GBW[0] GBW[1]
+ GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12]
+ GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+ BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+ BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+ BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+ BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+ BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+ BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+ BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+ BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+ BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+ BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1]
+ BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+ BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+ BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+ BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53]
+ BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63]
+ BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+ BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83]
+ BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93]
+ BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+ BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112]
+ BT[113] BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121]
+ BT[122] BT[123] BT[124] BT[125] BT[126] BT[127] BB_TOP[0] BB_TOP[1]
+ BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8]
+ BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20] BB_TOP[21]
+ BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26] BB_TOP[27]
+ BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] BB_TOP[32] BB_TOP[33]
+ BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38] BB_TOP[39]
+ BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44] BB_TOP[45]
+ BB_TOP[46] BB_TOP[47] BB_TOP[48] BB_TOP[49] BB_TOP[50] BB_TOP[51]
+ BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55] BB_TOP[56] BB_TOP[57]
+ BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61] BB_TOP[62] BB_TOP[63]
+ BB_TOP[64] BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69]
+ BB_TOP[70] BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75]
+ BB_TOP[76] BB_TOP[77] BB_TOP[78] BB_TOP[79] BB_TOP[80] BB_TOP[81]
+ BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86] BB_TOP[87]
+ BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92] BB_TOP[93]
+ BB_TOP[94] BB_TOP[95] BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99]
+ BB_TOP[100] BB_TOP[101] BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105]
+ BB_TOP[106] BB_TOP[107] BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111]
+ BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115] BB_TOP[116] BB_TOP[117]
+ BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121] BB_TOP[122] BB_TOP[123]
+ BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127] PD[0] PD[1] PD[2] PD[3] DBL
*.pininfo VDDA:B VSS:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B WL[5]:B
*.pininfo WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B WL[13]:B
*.pininfo WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B WL[20]:B
*.pininfo WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B WL[27]:B
*.pininfo WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B WL[34]:B
*.pininfo WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B WL[41]:B
*.pininfo WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B WL[48]:B
*.pininfo WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B WL[55]:B
*.pininfo WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B WL[62]:B
*.pininfo WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B WL[69]:B
*.pininfo WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B WL[76]:B
*.pininfo WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B WL[83]:B
*.pininfo WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B WL[90]:B
*.pininfo WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B WL[97]:B
*.pininfo WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B WL[104]:B
*.pininfo WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B WL[110]:B
*.pininfo WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B WL[116]:B
*.pininfo WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B WL[122]:B
*.pininfo WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B WL[128]:B
*.pininfo WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B WL[134]:B
*.pininfo WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B WL[140]:B
*.pininfo WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B WL[146]:B
*.pininfo WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B WL[152]:B
*.pininfo WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B WL[158]:B
*.pininfo WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B WL[164]:B
*.pininfo WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B WL[170]:B
*.pininfo WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B WL[176]:B
*.pininfo WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B WL[182]:B
*.pininfo WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B WL[188]:B
*.pininfo WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B WL[194]:B
*.pininfo WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B WL[200]:B
*.pininfo WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B WL[206]:B
*.pininfo WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B WL[212]:B
*.pininfo WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B WL[218]:B
*.pininfo WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B WL[224]:B
*.pininfo WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B WL[230]:B
*.pininfo WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B WL[236]:B
*.pininfo WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B WL[242]:B
*.pininfo WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B WL[248]:B
*.pininfo WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B WL[254]:B
*.pininfo WL[255]:B VNW:B PWR:B VSSX:B RWL:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B
*.pininfo GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B
*.pininfo GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B
*.pininfo GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B
*.pininfo GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B
*.pininfo GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B
*.pininfo GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B
*.pininfo GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B
*.pininfo GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B
*.pininfo GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B
*.pininfo BB[16]:B BB[17]:B BB[18]:B BB[19]:B BB[20]:B BB[21]:B BB[22]:B
*.pininfo BB[23]:B BB[24]:B BB[25]:B BB[26]:B BB[27]:B BB[28]:B BB[29]:B
*.pininfo BB[30]:B BB[31]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B BB[36]:B
*.pininfo BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B BB[43]:B
*.pininfo BB[44]:B BB[45]:B BB[46]:B BB[47]:B BB[48]:B BB[49]:B BB[50]:B
*.pininfo BB[51]:B BB[52]:B BB[53]:B BB[54]:B BB[55]:B BB[56]:B BB[57]:B
*.pininfo BB[58]:B BB[59]:B BB[60]:B BB[61]:B BB[62]:B BB[63]:B BB[64]:B
*.pininfo BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B BB[71]:B
*.pininfo BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B BB[78]:B
*.pininfo BB[79]:B BB[80]:B BB[81]:B BB[82]:B BB[83]:B BB[84]:B BB[85]:B
*.pininfo BB[86]:B BB[87]:B BB[88]:B BB[89]:B BB[90]:B BB[91]:B BB[92]:B
*.pininfo BB[93]:B BB[94]:B BB[95]:B BB[96]:B BB[97]:B BB[98]:B BB[99]:B
*.pininfo BB[100]:B BB[101]:B BB[102]:B BB[103]:B BB[104]:B BB[105]:B
*.pininfo BB[106]:B BB[107]:B BB[108]:B BB[109]:B BB[110]:B BB[111]:B
*.pininfo BB[112]:B BB[113]:B BB[114]:B BB[115]:B BB[116]:B BB[117]:B
*.pininfo BB[118]:B BB[119]:B BB[120]:B BB[121]:B BB[122]:B BB[123]:B
*.pininfo BB[124]:B BB[125]:B BB[126]:B BB[127]:B BT[0]:B BT[1]:B BT[2]:B
*.pininfo BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B BT[9]:B BT[10]:B
*.pininfo BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B BT[16]:B BT[17]:B
*.pininfo BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B BT[23]:B BT[24]:B
*.pininfo BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B BT[30]:B BT[31]:B
*.pininfo BT[32]:B BT[33]:B BT[34]:B BT[35]:B BT[36]:B BT[37]:B BT[38]:B
*.pininfo BT[39]:B BT[40]:B BT[41]:B BT[42]:B BT[43]:B BT[44]:B BT[45]:B
*.pininfo BT[46]:B BT[47]:B BT[48]:B BT[49]:B BT[50]:B BT[51]:B BT[52]:B
*.pininfo BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B BT[58]:B BT[59]:B
*.pininfo BT[60]:B BT[61]:B BT[62]:B BT[63]:B BT[64]:B BT[65]:B BT[66]:B
*.pininfo BT[67]:B BT[68]:B BT[69]:B BT[70]:B BT[71]:B BT[72]:B BT[73]:B
*.pininfo BT[74]:B BT[75]:B BT[76]:B BT[77]:B BT[78]:B BT[79]:B BT[80]:B
*.pininfo BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B BT[86]:B BT[87]:B
*.pininfo BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B BT[93]:B BT[94]:B
*.pininfo BT[95]:B BT[96]:B BT[97]:B BT[98]:B BT[99]:B BT[100]:B BT[101]:B
*.pininfo BT[102]:B BT[103]:B BT[104]:B BT[105]:B BT[106]:B BT[107]:B
*.pininfo BT[108]:B BT[109]:B BT[110]:B BT[111]:B BT[112]:B BT[113]:B
*.pininfo BT[114]:B BT[115]:B BT[116]:B BT[117]:B BT[118]:B BT[119]:B
*.pininfo BT[120]:B BT[121]:B BT[122]:B BT[123]:B BT[124]:B BT[125]:B
*.pininfo BT[126]:B BT[127]:B BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B
*.pininfo BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BB_TOP[8]:B
*.pininfo BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B BB_TOP[12]:B BB_TOP[13]:B
*.pininfo BB_TOP[14]:B BB_TOP[15]:B BB_TOP[16]:B BB_TOP[17]:B BB_TOP[18]:B
*.pininfo BB_TOP[19]:B BB_TOP[20]:B BB_TOP[21]:B BB_TOP[22]:B BB_TOP[23]:B
*.pininfo BB_TOP[24]:B BB_TOP[25]:B BB_TOP[26]:B BB_TOP[27]:B BB_TOP[28]:B
*.pininfo BB_TOP[29]:B BB_TOP[30]:B BB_TOP[31]:B BB_TOP[32]:B BB_TOP[33]:B
*.pininfo BB_TOP[34]:B BB_TOP[35]:B BB_TOP[36]:B BB_TOP[37]:B BB_TOP[38]:B
*.pininfo BB_TOP[39]:B BB_TOP[40]:B BB_TOP[41]:B BB_TOP[42]:B BB_TOP[43]:B
*.pininfo BB_TOP[44]:B BB_TOP[45]:B BB_TOP[46]:B BB_TOP[47]:B BB_TOP[48]:B
*.pininfo BB_TOP[49]:B BB_TOP[50]:B BB_TOP[51]:B BB_TOP[52]:B BB_TOP[53]:B
*.pininfo BB_TOP[54]:B BB_TOP[55]:B BB_TOP[56]:B BB_TOP[57]:B BB_TOP[58]:B
*.pininfo BB_TOP[59]:B BB_TOP[60]:B BB_TOP[61]:B BB_TOP[62]:B BB_TOP[63]:B
*.pininfo BB_TOP[64]:B BB_TOP[65]:B BB_TOP[66]:B BB_TOP[67]:B BB_TOP[68]:B
*.pininfo BB_TOP[69]:B BB_TOP[70]:B BB_TOP[71]:B BB_TOP[72]:B BB_TOP[73]:B
*.pininfo BB_TOP[74]:B BB_TOP[75]:B BB_TOP[76]:B BB_TOP[77]:B BB_TOP[78]:B
*.pininfo BB_TOP[79]:B BB_TOP[80]:B BB_TOP[81]:B BB_TOP[82]:B BB_TOP[83]:B
*.pininfo BB_TOP[84]:B BB_TOP[85]:B BB_TOP[86]:B BB_TOP[87]:B BB_TOP[88]:B
*.pininfo BB_TOP[89]:B BB_TOP[90]:B BB_TOP[91]:B BB_TOP[92]:B BB_TOP[93]:B
*.pininfo BB_TOP[94]:B BB_TOP[95]:B BB_TOP[96]:B BB_TOP[97]:B BB_TOP[98]:B
*.pininfo BB_TOP[99]:B BB_TOP[100]:B BB_TOP[101]:B BB_TOP[102]:B
*.pininfo BB_TOP[103]:B BB_TOP[104]:B BB_TOP[105]:B BB_TOP[106]:B
*.pininfo BB_TOP[107]:B BB_TOP[108]:B BB_TOP[109]:B BB_TOP[110]:B
*.pininfo BB_TOP[111]:B BB_TOP[112]:B BB_TOP[113]:B BB_TOP[114]:B
*.pininfo BB_TOP[115]:B BB_TOP[116]:B BB_TOP[117]:B BB_TOP[118]:B
*.pininfo BB_TOP[119]:B BB_TOP[120]:B BB_TOP[121]:B BB_TOP[122]:B
*.pininfo BB_TOP[123]:B BB_TOP[124]:B BB_TOP[125]:B BB_TOP[126]:B
*.pininfo BB_TOP[127]:B PD[0]:B PD[1]:B PD[2]:B PD[3]:B DBL:B
XXspram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGER_0 VDDA VSSX VSS RWL
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGER m=1
XXspram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY_0 GD[0] GBW[0] VSSX
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] BB[0] BB[1] BB[2]
+ BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+ BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] RWL BB_TOP[0] BB_TOP[1] BB_TOP[2]
+ BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9]
+ BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] WL[0]
+ WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+ WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+ WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+ WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+ WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+ WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+ WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72]
+ WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82]
+ WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92]
+ WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102]
+ WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111]
+ WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120]
+ WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129]
+ WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138]
+ WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147]
+ WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156]
+ WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165]
+ WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174]
+ WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183]
+ WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192]
+ WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201]
+ WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210]
+ WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219]
+ WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228]
+ WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237]
+ WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246]
+ WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW
+ VSS VDDA PWR GD[1] GBW[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+ BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18]
+ BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+ BT[29] BT[30] BT[31] BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20]
+ BB_TOP[21] BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26]
+ BB_TOP[27] BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] GD[2] GBW[2] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] BB[32] BB[33] BB[34]
+ BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44]
+ BB[45] BB[46] BB[47] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38]
+ BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BB_TOP[32]
+ BB_TOP[33] BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38]
+ BB_TOP[39] BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44]
+ BB_TOP[45] BB_TOP[46] BB_TOP[47] GD[3] GBW[3] GRD0[12] GRD0[13] GRD0[14]
+ GRD0[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD3[12] GRD3[13] GRD3[14] GRD3[15] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+ BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BB_TOP[48]
+ BB_TOP[49] BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54]
+ BB_TOP[55] BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60]
+ BB_TOP[61] BB_TOP[62] BB_TOP[63] GD[4] GBW[4] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19] BB[64] BB[65] BB[66] BB[67]
+ BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77]
+ BB[78] BB[79] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71]
+ BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BB_TOP[64]
+ BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69] BB_TOP[70]
+ BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75] BB_TOP[76]
+ BB_TOP[77] BB_TOP[78] BB_TOP[79] GD[5] GBW[5] GRD0[20] GRD0[21] GRD0[22]
+ GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] BB[80] BB[81] BB[82] BB[83]
+ BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+ BB[94] BB[95] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87]
+ BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BB_TOP[80]
+ BB_TOP[81] BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86]
+ BB_TOP[87] BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92]
+ BB_TOP[93] BB_TOP[94] BB_TOP[95] GD[6] GBW[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] BB[96] BB[97] BB[98] BB[99]
+ BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+ BB[109] BB[110] BB[111] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102]
+ BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111]
+ BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101]
+ BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107]
+ BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111] GD[7] GBW[7] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29] GRD3[30] GRD3[31] BB[112]
+ BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+ BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[112] BT[113] BT[114]
+ BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+ BT[124] BT[125] BT[126] BT[127] BB_TOP[112] BB_TOP[113] BB_TOP[114]
+ BB_TOP[115] BB_TOP[116] BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120]
+ BB_TOP[121] BB_TOP[122] BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126]
+ BB_TOP[127] spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_BITARY m=1
XXspram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGEL_0 DBL VDDA VSSX VSS RWL
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR PD[0] PD[1] PD[2] PD[3]
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_ARYEDGEL m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA

.subckt spram_4096x16m16b1pm2re1RE1M16_B1BOT VSS VDDA PD[0] PD[1] PD[2] PD[3]
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+ BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19]
+ BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29]
+ BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39]
+ BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+ BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59]
+ BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69]
+ BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79]
+ BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89]
+ BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99]
+ BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+ BB[109] BB[110] BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117]
+ BB[118] BB[119] BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126]
+ BB[127] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10]
+ BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20]
+ BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30]
+ BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+ BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50]
+ BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60]
+ BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70]
+ BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80]
+ BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+ BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+ BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+ BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117] BT[118]
+ BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126] BT[127]
+ GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2]
+ GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4]
+ GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] VSSX DBL
+ BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6]
+ BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13]
+ BB_TOP[14] BB_TOP[15] BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19]
+ BB_TOP[20] BB_TOP[21] BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25]
+ BB_TOP[26] BB_TOP[27] BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31]
+ BB_TOP[32] BB_TOP[33] BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37]
+ BB_TOP[38] BB_TOP[39] BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43]
+ BB_TOP[44] BB_TOP[45] BB_TOP[46] BB_TOP[47] BB_TOP[48] BB_TOP[49]
+ BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55]
+ BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61]
+ BB_TOP[62] BB_TOP[63] BB_TOP[64] BB_TOP[65] BB_TOP[66] BB_TOP[67]
+ BB_TOP[68] BB_TOP[69] BB_TOP[70] BB_TOP[71] BB_TOP[72] BB_TOP[73]
+ BB_TOP[74] BB_TOP[75] BB_TOP[76] BB_TOP[77] BB_TOP[78] BB_TOP[79]
+ BB_TOP[80] BB_TOP[81] BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85]
+ BB_TOP[86] BB_TOP[87] BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91]
+ BB_TOP[92] BB_TOP[93] BB_TOP[94] BB_TOP[95] BB_TOP[96] BB_TOP[97]
+ BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101] BB_TOP[102] BB_TOP[103]
+ BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107] BB_TOP[108] BB_TOP[109]
+ BB_TOP[110] BB_TOP[111] BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115]
+ BB_TOP[116] BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121]
+ BB_TOP[122] BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127] RWL
*.pininfo VSS:B VDDA:B PD[0]:B PD[1]:B PD[2]:B PD[3]:B WL[0]:B WL[1]:B
*.pininfo WL[2]:B WL[3]:B WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B
*.pininfo WL[10]:B WL[11]:B WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B
*.pininfo WL[17]:B WL[18]:B WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B
*.pininfo WL[24]:B WL[25]:B WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B
*.pininfo WL[31]:B WL[32]:B WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B
*.pininfo WL[38]:B WL[39]:B WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B
*.pininfo WL[45]:B WL[46]:B WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B
*.pininfo WL[52]:B WL[53]:B WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B
*.pininfo WL[59]:B WL[60]:B WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B
*.pininfo WL[66]:B WL[67]:B WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B
*.pininfo WL[73]:B WL[74]:B WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B
*.pininfo WL[80]:B WL[81]:B WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B
*.pininfo WL[87]:B WL[88]:B WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B
*.pininfo WL[94]:B WL[95]:B WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B
*.pininfo WL[101]:B WL[102]:B WL[103]:B WL[104]:B WL[105]:B WL[106]:B
*.pininfo WL[107]:B WL[108]:B WL[109]:B WL[110]:B WL[111]:B WL[112]:B
*.pininfo WL[113]:B WL[114]:B WL[115]:B WL[116]:B WL[117]:B WL[118]:B
*.pininfo WL[119]:B WL[120]:B WL[121]:B WL[122]:B WL[123]:B WL[124]:B
*.pininfo WL[125]:B WL[126]:B WL[127]:B WL[128]:B WL[129]:B WL[130]:B
*.pininfo WL[131]:B WL[132]:B WL[133]:B WL[134]:B WL[135]:B WL[136]:B
*.pininfo WL[137]:B WL[138]:B WL[139]:B WL[140]:B WL[141]:B WL[142]:B
*.pininfo WL[143]:B WL[144]:B WL[145]:B WL[146]:B WL[147]:B WL[148]:B
*.pininfo WL[149]:B WL[150]:B WL[151]:B WL[152]:B WL[153]:B WL[154]:B
*.pininfo WL[155]:B WL[156]:B WL[157]:B WL[158]:B WL[159]:B WL[160]:B
*.pininfo WL[161]:B WL[162]:B WL[163]:B WL[164]:B WL[165]:B WL[166]:B
*.pininfo WL[167]:B WL[168]:B WL[169]:B WL[170]:B WL[171]:B WL[172]:B
*.pininfo WL[173]:B WL[174]:B WL[175]:B WL[176]:B WL[177]:B WL[178]:B
*.pininfo WL[179]:B WL[180]:B WL[181]:B WL[182]:B WL[183]:B WL[184]:B
*.pininfo WL[185]:B WL[186]:B WL[187]:B WL[188]:B WL[189]:B WL[190]:B
*.pininfo WL[191]:B WL[192]:B WL[193]:B WL[194]:B WL[195]:B WL[196]:B
*.pininfo WL[197]:B WL[198]:B WL[199]:B WL[200]:B WL[201]:B WL[202]:B
*.pininfo WL[203]:B WL[204]:B WL[205]:B WL[206]:B WL[207]:B WL[208]:B
*.pininfo WL[209]:B WL[210]:B WL[211]:B WL[212]:B WL[213]:B WL[214]:B
*.pininfo WL[215]:B WL[216]:B WL[217]:B WL[218]:B WL[219]:B WL[220]:B
*.pininfo WL[221]:B WL[222]:B WL[223]:B WL[224]:B WL[225]:B WL[226]:B
*.pininfo WL[227]:B WL[228]:B WL[229]:B WL[230]:B WL[231]:B WL[232]:B
*.pininfo WL[233]:B WL[234]:B WL[235]:B WL[236]:B WL[237]:B WL[238]:B
*.pininfo WL[239]:B WL[240]:B WL[241]:B WL[242]:B WL[243]:B WL[244]:B
*.pininfo WL[245]:B WL[246]:B WL[247]:B WL[248]:B WL[249]:B WL[250]:B
*.pininfo WL[251]:B WL[252]:B WL[253]:B WL[254]:B WL[255]:B VNW:B PWR:B
*.pininfo BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.pininfo BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.pininfo BB[15]:B BB[16]:B BB[17]:B BB[18]:B BB[19]:B BB[20]:B BB[21]:B
*.pininfo BB[22]:B BB[23]:B BB[24]:B BB[25]:B BB[26]:B BB[27]:B BB[28]:B
*.pininfo BB[29]:B BB[30]:B BB[31]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B
*.pininfo BB[36]:B BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B
*.pininfo BB[43]:B BB[44]:B BB[45]:B BB[46]:B BB[47]:B BB[48]:B BB[49]:B
*.pininfo BB[50]:B BB[51]:B BB[52]:B BB[53]:B BB[54]:B BB[55]:B BB[56]:B
*.pininfo BB[57]:B BB[58]:B BB[59]:B BB[60]:B BB[61]:B BB[62]:B BB[63]:B
*.pininfo BB[64]:B BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B
*.pininfo BB[71]:B BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B
*.pininfo BB[78]:B BB[79]:B BB[80]:B BB[81]:B BB[82]:B BB[83]:B BB[84]:B
*.pininfo BB[85]:B BB[86]:B BB[87]:B BB[88]:B BB[89]:B BB[90]:B BB[91]:B
*.pininfo BB[92]:B BB[93]:B BB[94]:B BB[95]:B BB[96]:B BB[97]:B BB[98]:B
*.pininfo BB[99]:B BB[100]:B BB[101]:B BB[102]:B BB[103]:B BB[104]:B
*.pininfo BB[105]:B BB[106]:B BB[107]:B BB[108]:B BB[109]:B BB[110]:B
*.pininfo BB[111]:B BB[112]:B BB[113]:B BB[114]:B BB[115]:B BB[116]:B
*.pininfo BB[117]:B BB[118]:B BB[119]:B BB[120]:B BB[121]:B BB[122]:B
*.pininfo BB[123]:B BB[124]:B BB[125]:B BB[126]:B BB[127]:B BT[0]:B BT[1]:B
*.pininfo BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B BT[9]:B
*.pininfo BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B BT[16]:B
*.pininfo BT[17]:B BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B BT[23]:B
*.pininfo BT[24]:B BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B BT[30]:B
*.pininfo BT[31]:B BT[32]:B BT[33]:B BT[34]:B BT[35]:B BT[36]:B BT[37]:B
*.pininfo BT[38]:B BT[39]:B BT[40]:B BT[41]:B BT[42]:B BT[43]:B BT[44]:B
*.pininfo BT[45]:B BT[46]:B BT[47]:B BT[48]:B BT[49]:B BT[50]:B BT[51]:B
*.pininfo BT[52]:B BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B BT[58]:B
*.pininfo BT[59]:B BT[60]:B BT[61]:B BT[62]:B BT[63]:B BT[64]:B BT[65]:B
*.pininfo BT[66]:B BT[67]:B BT[68]:B BT[69]:B BT[70]:B BT[71]:B BT[72]:B
*.pininfo BT[73]:B BT[74]:B BT[75]:B BT[76]:B BT[77]:B BT[78]:B BT[79]:B
*.pininfo BT[80]:B BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B BT[86]:B
*.pininfo BT[87]:B BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B BT[93]:B
*.pininfo BT[94]:B BT[95]:B BT[96]:B BT[97]:B BT[98]:B BT[99]:B BT[100]:B
*.pininfo BT[101]:B BT[102]:B BT[103]:B BT[104]:B BT[105]:B BT[106]:B
*.pininfo BT[107]:B BT[108]:B BT[109]:B BT[110]:B BT[111]:B BT[112]:B
*.pininfo BT[113]:B BT[114]:B BT[115]:B BT[116]:B BT[117]:B BT[118]:B
*.pininfo BT[119]:B BT[120]:B BT[121]:B BT[122]:B BT[123]:B BT[124]:B
*.pininfo BT[125]:B BT[126]:B BT[127]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B
*.pininfo GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B
*.pininfo GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B
*.pininfo GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B
*.pininfo GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B
*.pininfo GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B
*.pininfo GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B
*.pininfo GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B
*.pininfo GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B
*.pininfo GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B VSSX:B DBL:B
*.pininfo BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B
*.pininfo BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BB_TOP[8]:B BB_TOP[9]:B
*.pininfo BB_TOP[10]:B BB_TOP[11]:B BB_TOP[12]:B BB_TOP[13]:B BB_TOP[14]:B
*.pininfo BB_TOP[15]:B BB_TOP[16]:B BB_TOP[17]:B BB_TOP[18]:B BB_TOP[19]:B
*.pininfo BB_TOP[20]:B BB_TOP[21]:B BB_TOP[22]:B BB_TOP[23]:B BB_TOP[24]:B
*.pininfo BB_TOP[25]:B BB_TOP[26]:B BB_TOP[27]:B BB_TOP[28]:B BB_TOP[29]:B
*.pininfo BB_TOP[30]:B BB_TOP[31]:B BB_TOP[32]:B BB_TOP[33]:B BB_TOP[34]:B
*.pininfo BB_TOP[35]:B BB_TOP[36]:B BB_TOP[37]:B BB_TOP[38]:B BB_TOP[39]:B
*.pininfo BB_TOP[40]:B BB_TOP[41]:B BB_TOP[42]:B BB_TOP[43]:B BB_TOP[44]:B
*.pininfo BB_TOP[45]:B BB_TOP[46]:B BB_TOP[47]:B BB_TOP[48]:B BB_TOP[49]:B
*.pininfo BB_TOP[50]:B BB_TOP[51]:B BB_TOP[52]:B BB_TOP[53]:B BB_TOP[54]:B
*.pininfo BB_TOP[55]:B BB_TOP[56]:B BB_TOP[57]:B BB_TOP[58]:B BB_TOP[59]:B
*.pininfo BB_TOP[60]:B BB_TOP[61]:B BB_TOP[62]:B BB_TOP[63]:B BB_TOP[64]:B
*.pininfo BB_TOP[65]:B BB_TOP[66]:B BB_TOP[67]:B BB_TOP[68]:B BB_TOP[69]:B
*.pininfo BB_TOP[70]:B BB_TOP[71]:B BB_TOP[72]:B BB_TOP[73]:B BB_TOP[74]:B
*.pininfo BB_TOP[75]:B BB_TOP[76]:B BB_TOP[77]:B BB_TOP[78]:B BB_TOP[79]:B
*.pininfo BB_TOP[80]:B BB_TOP[81]:B BB_TOP[82]:B BB_TOP[83]:B BB_TOP[84]:B
*.pininfo BB_TOP[85]:B BB_TOP[86]:B BB_TOP[87]:B BB_TOP[88]:B BB_TOP[89]:B
*.pininfo BB_TOP[90]:B BB_TOP[91]:B BB_TOP[92]:B BB_TOP[93]:B BB_TOP[94]:B
*.pininfo BB_TOP[95]:B BB_TOP[96]:B BB_TOP[97]:B BB_TOP[98]:B BB_TOP[99]:B
*.pininfo BB_TOP[100]:B BB_TOP[101]:B BB_TOP[102]:B BB_TOP[103]:B
*.pininfo BB_TOP[104]:B BB_TOP[105]:B BB_TOP[106]:B BB_TOP[107]:B
*.pininfo BB_TOP[108]:B BB_TOP[109]:B BB_TOP[110]:B BB_TOP[111]:B
*.pininfo BB_TOP[112]:B BB_TOP[113]:B BB_TOP[114]:B BB_TOP[115]:B
*.pininfo BB_TOP[116]:B BB_TOP[117]:B BB_TOP[118]:B BB_TOP[119]:B
*.pininfo BB_TOP[120]:B BB_TOP[121]:B BB_TOP[122]:B BB_TOP[123]:B
*.pininfo BB_TOP[124]:B BB_TOP[125]:B BB_TOP[126]:B BB_TOP[127]:B RWL:B
XXspram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA_0 VDDA VSS WL[0] WL[1] WL[2]
+ WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW PWR
+ VSSX RWL GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GBW[0] GBW[1]
+ GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12]
+ GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+ BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+ BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+ BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+ BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+ BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+ BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+ BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+ BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+ BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+ BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1]
+ BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+ BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+ BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+ BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53]
+ BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63]
+ BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+ BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83]
+ BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93]
+ BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+ BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112]
+ BT[113] BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121]
+ BT[122] BT[123] BT[124] BT[125] BT[126] BT[127] BB_TOP[0] BB_TOP[1]
+ BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8]
+ BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20] BB_TOP[21]
+ BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26] BB_TOP[27]
+ BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] BB_TOP[32] BB_TOP[33]
+ BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38] BB_TOP[39]
+ BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44] BB_TOP[45]
+ BB_TOP[46] BB_TOP[47] BB_TOP[48] BB_TOP[49] BB_TOP[50] BB_TOP[51]
+ BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55] BB_TOP[56] BB_TOP[57]
+ BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61] BB_TOP[62] BB_TOP[63]
+ BB_TOP[64] BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69]
+ BB_TOP[70] BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75]
+ BB_TOP[76] BB_TOP[77] BB_TOP[78] BB_TOP[79] BB_TOP[80] BB_TOP[81]
+ BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86] BB_TOP[87]
+ BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92] BB_TOP[93]
+ BB_TOP[94] BB_TOP[95] BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99]
+ BB_TOP[100] BB_TOP[101] BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105]
+ BB_TOP[106] BB_TOP[107] BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111]
+ BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115] BB_TOP[116] BB_TOP[117]
+ BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121] BB_TOP[122] BB_TOP[123]
+ BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127] PD[0] PD[1] PD[2] PD[3] DBL
+ spram_4096x16m16b1pm2re1RE1M16_B1BOTARRAYA m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1BOT

.subckt spram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_R BB[0] BB[1] BB[2]
+ BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23]
+ BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33]
+ BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+ BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+ BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63]
+ BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73]
+ BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83]
+ BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+ BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+ BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112]
+ BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+ BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3]
+ BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+ BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+ BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+ BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+ BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+ BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+ BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74]
+ BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+ BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+ BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104]
+ BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113]
+ BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122]
+ BT[123] BT[124] BT[125] BT[126] BT[127] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4]
+ GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16]
+ GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9]
+ GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17]
+ GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25]
+ GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1]
+ GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10]
+ GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11]
+ GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27]
+ GRD3[28] GRD3[29] GRD3[30] GRD3[31] VSS VSSX VDDA RWL DBL PD[0] PD[1] PD[2]
+ PD[3] WLC[0] WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6] WLC[7] WLC[8] WLC[9]
+ WLC[10] WLC[11] WLC[12] WLC[13] WLC[14] WLC[15] WLC[16] WLC[17] WLC[18]
+ WLC[19] WLC[20] WLC[21] WLC[22] WLC[23] WLC[24] WLC[25] WLC[26] WLC[27]
+ WLC[28] WLC[29] WLC[30] WLC[31] WLC[32] WLC[33] WLC[34] WLC[35] WLC[36]
+ WLC[37] WLC[38] WLC[39] WLC[40] WLC[41] WLC[42] WLC[43] WLC[44] WLC[45]
+ WLC[46] WLC[47] WLC[48] WLC[49] WLC[50] WLC[51] WLC[52] WLC[53] WLC[54]
+ WLC[55] WLC[56] WLC[57] WLC[58] WLC[59] WLC[60] WLC[61] WLC[62] WLC[63]
+ WLC[64] WLC[65] WLC[66] WLC[67] WLC[68] WLC[69] WLC[70] WLC[71] WLC[72]
+ WLC[73] WLC[74] WLC[75] WLC[76] WLC[77] WLC[78] WLC[79] WLC[80] WLC[81]
+ WLC[82] WLC[83] WLC[84] WLC[85] WLC[86] WLC[87] WLC[88] WLC[89] WLC[90]
+ WLC[91] WLC[92] WLC[93] WLC[94] WLC[95] WLC[96] WLC[97] WLC[98] WLC[99]
+ WLC[100] WLC[101] WLC[102] WLC[103] WLC[104] WLC[105] WLC[106] WLC[107]
+ WLC[108] WLC[109] WLC[110] WLC[111] WLC[112] WLC[113] WLC[114] WLC[115]
+ WLC[116] WLC[117] WLC[118] WLC[119] WLC[120] WLC[121] WLC[122] WLC[123]
+ WLC[124] WLC[125] WLC[126] WLC[127] WLC[128] WLC[129] WLC[130] WLC[131]
+ WLC[132] WLC[133] WLC[134] WLC[135] WLC[136] WLC[137] WLC[138] WLC[139]
+ WLC[140] WLC[141] WLC[142] WLC[143] WLC[144] WLC[145] WLC[146] WLC[147]
+ WLC[148] WLC[149] WLC[150] WLC[151] WLC[152] WLC[153] WLC[154] WLC[155]
+ WLC[156] WLC[157] WLC[158] WLC[159] WLC[160] WLC[161] WLC[162] WLC[163]
+ WLC[164] WLC[165] WLC[166] WLC[167] WLC[168] WLC[169] WLC[170] WLC[171]
+ WLC[172] WLC[173] WLC[174] WLC[175] WLC[176] WLC[177] WLC[178] WLC[179]
+ WLC[180] WLC[181] WLC[182] WLC[183] WLC[184] WLC[185] WLC[186] WLC[187]
+ WLC[188] WLC[189] WLC[190] WLC[191] WLC[192] WLC[193] WLC[194] WLC[195]
+ WLC[196] WLC[197] WLC[198] WLC[199] WLC[200] WLC[201] WLC[202] WLC[203]
+ WLC[204] WLC[205] WLC[206] WLC[207] WLC[208] WLC[209] WLC[210] WLC[211]
+ WLC[212] WLC[213] WLC[214] WLC[215] WLC[216] WLC[217] WLC[218] WLC[219]
+ WLC[220] WLC[221] WLC[222] WLC[223] WLC[224] WLC[225] WLC[226] WLC[227]
+ WLC[228] WLC[229] WLC[230] WLC[231] WLC[232] WLC[233] WLC[234] WLC[235]
+ WLC[236] WLC[237] WLC[238] WLC[239] WLC[240] WLC[241] WLC[242] WLC[243]
+ WLC[244] WLC[245] WLC[246] WLC[247] WLC[248] WLC[249] WLC[250] WLC[251]
+ WLC[252] WLC[253] WLC[254] WLC[255] VNW PWR
*.pininfo BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.pininfo BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.pininfo BB[15]:B BB[16]:B BB[17]:B BB[18]:B BB[19]:B BB[20]:B BB[21]:B
*.pininfo BB[22]:B BB[23]:B BB[24]:B BB[25]:B BB[26]:B BB[27]:B BB[28]:B
*.pininfo BB[29]:B BB[30]:B BB[31]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B
*.pininfo BB[36]:B BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B
*.pininfo BB[43]:B BB[44]:B BB[45]:B BB[46]:B BB[47]:B BB[48]:B BB[49]:B
*.pininfo BB[50]:B BB[51]:B BB[52]:B BB[53]:B BB[54]:B BB[55]:B BB[56]:B
*.pininfo BB[57]:B BB[58]:B BB[59]:B BB[60]:B BB[61]:B BB[62]:B BB[63]:B
*.pininfo BB[64]:B BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B
*.pininfo BB[71]:B BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B
*.pininfo BB[78]:B BB[79]:B BB[80]:B BB[81]:B BB[82]:B BB[83]:B BB[84]:B
*.pininfo BB[85]:B BB[86]:B BB[87]:B BB[88]:B BB[89]:B BB[90]:B BB[91]:B
*.pininfo BB[92]:B BB[93]:B BB[94]:B BB[95]:B BB[96]:B BB[97]:B BB[98]:B
*.pininfo BB[99]:B BB[100]:B BB[101]:B BB[102]:B BB[103]:B BB[104]:B
*.pininfo BB[105]:B BB[106]:B BB[107]:B BB[108]:B BB[109]:B BB[110]:B
*.pininfo BB[111]:B BB[112]:B BB[113]:B BB[114]:B BB[115]:B BB[116]:B
*.pininfo BB[117]:B BB[118]:B BB[119]:B BB[120]:B BB[121]:B BB[122]:B
*.pininfo BB[123]:B BB[124]:B BB[125]:B BB[126]:B BB[127]:B BT[0]:B BT[1]:B
*.pininfo BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B BT[9]:B
*.pininfo BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B BT[16]:B
*.pininfo BT[17]:B BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B BT[23]:B
*.pininfo BT[24]:B BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B BT[30]:B
*.pininfo BT[31]:B BT[32]:B BT[33]:B BT[34]:B BT[35]:B BT[36]:B BT[37]:B
*.pininfo BT[38]:B BT[39]:B BT[40]:B BT[41]:B BT[42]:B BT[43]:B BT[44]:B
*.pininfo BT[45]:B BT[46]:B BT[47]:B BT[48]:B BT[49]:B BT[50]:B BT[51]:B
*.pininfo BT[52]:B BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B BT[58]:B
*.pininfo BT[59]:B BT[60]:B BT[61]:B BT[62]:B BT[63]:B BT[64]:B BT[65]:B
*.pininfo BT[66]:B BT[67]:B BT[68]:B BT[69]:B BT[70]:B BT[71]:B BT[72]:B
*.pininfo BT[73]:B BT[74]:B BT[75]:B BT[76]:B BT[77]:B BT[78]:B BT[79]:B
*.pininfo BT[80]:B BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B BT[86]:B
*.pininfo BT[87]:B BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B BT[93]:B
*.pininfo BT[94]:B BT[95]:B BT[96]:B BT[97]:B BT[98]:B BT[99]:B BT[100]:B
*.pininfo BT[101]:B BT[102]:B BT[103]:B BT[104]:B BT[105]:B BT[106]:B
*.pininfo BT[107]:B BT[108]:B BT[109]:B BT[110]:B BT[111]:B BT[112]:B
*.pininfo BT[113]:B BT[114]:B BT[115]:B BT[116]:B BT[117]:B BT[118]:B
*.pininfo BT[119]:B BT[120]:B BT[121]:B BT[122]:B BT[123]:B BT[124]:B
*.pininfo BT[125]:B BT[126]:B BT[127]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B
*.pininfo GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B
*.pininfo GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B
*.pininfo GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B
*.pininfo GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B
*.pininfo GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B
*.pininfo GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B
*.pininfo GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B
*.pininfo GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B
*.pininfo GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B VSS:B VSSX:B
*.pininfo VDDA:B RWL:B DBL:B PD[0]:B PD[1]:B PD[2]:B PD[3]:B WLC[0]:B
*.pininfo WLC[1]:B WLC[2]:B WLC[3]:B WLC[4]:B WLC[5]:B WLC[6]:B WLC[7]:B
*.pininfo WLC[8]:B WLC[9]:B WLC[10]:B WLC[11]:B WLC[12]:B WLC[13]:B WLC[14]:B
*.pininfo WLC[15]:B WLC[16]:B WLC[17]:B WLC[18]:B WLC[19]:B WLC[20]:B
*.pininfo WLC[21]:B WLC[22]:B WLC[23]:B WLC[24]:B WLC[25]:B WLC[26]:B
*.pininfo WLC[27]:B WLC[28]:B WLC[29]:B WLC[30]:B WLC[31]:B WLC[32]:B
*.pininfo WLC[33]:B WLC[34]:B WLC[35]:B WLC[36]:B WLC[37]:B WLC[38]:B
*.pininfo WLC[39]:B WLC[40]:B WLC[41]:B WLC[42]:B WLC[43]:B WLC[44]:B
*.pininfo WLC[45]:B WLC[46]:B WLC[47]:B WLC[48]:B WLC[49]:B WLC[50]:B
*.pininfo WLC[51]:B WLC[52]:B WLC[53]:B WLC[54]:B WLC[55]:B WLC[56]:B
*.pininfo WLC[57]:B WLC[58]:B WLC[59]:B WLC[60]:B WLC[61]:B WLC[62]:B
*.pininfo WLC[63]:B WLC[64]:B WLC[65]:B WLC[66]:B WLC[67]:B WLC[68]:B
*.pininfo WLC[69]:B WLC[70]:B WLC[71]:B WLC[72]:B WLC[73]:B WLC[74]:B
*.pininfo WLC[75]:B WLC[76]:B WLC[77]:B WLC[78]:B WLC[79]:B WLC[80]:B
*.pininfo WLC[81]:B WLC[82]:B WLC[83]:B WLC[84]:B WLC[85]:B WLC[86]:B
*.pininfo WLC[87]:B WLC[88]:B WLC[89]:B WLC[90]:B WLC[91]:B WLC[92]:B
*.pininfo WLC[93]:B WLC[94]:B WLC[95]:B WLC[96]:B WLC[97]:B WLC[98]:B
*.pininfo WLC[99]:B WLC[100]:B WLC[101]:B WLC[102]:B WLC[103]:B WLC[104]:B
*.pininfo WLC[105]:B WLC[106]:B WLC[107]:B WLC[108]:B WLC[109]:B WLC[110]:B
*.pininfo WLC[111]:B WLC[112]:B WLC[113]:B WLC[114]:B WLC[115]:B WLC[116]:B
*.pininfo WLC[117]:B WLC[118]:B WLC[119]:B WLC[120]:B WLC[121]:B WLC[122]:B
*.pininfo WLC[123]:B WLC[124]:B WLC[125]:B WLC[126]:B WLC[127]:B WLC[128]:B
*.pininfo WLC[129]:B WLC[130]:B WLC[131]:B WLC[132]:B WLC[133]:B WLC[134]:B
*.pininfo WLC[135]:B WLC[136]:B WLC[137]:B WLC[138]:B WLC[139]:B WLC[140]:B
*.pininfo WLC[141]:B WLC[142]:B WLC[143]:B WLC[144]:B WLC[145]:B WLC[146]:B
*.pininfo WLC[147]:B WLC[148]:B WLC[149]:B WLC[150]:B WLC[151]:B WLC[152]:B
*.pininfo WLC[153]:B WLC[154]:B WLC[155]:B WLC[156]:B WLC[157]:B WLC[158]:B
*.pininfo WLC[159]:B WLC[160]:B WLC[161]:B WLC[162]:B WLC[163]:B WLC[164]:B
*.pininfo WLC[165]:B WLC[166]:B WLC[167]:B WLC[168]:B WLC[169]:B WLC[170]:B
*.pininfo WLC[171]:B WLC[172]:B WLC[173]:B WLC[174]:B WLC[175]:B WLC[176]:B
*.pininfo WLC[177]:B WLC[178]:B WLC[179]:B WLC[180]:B WLC[181]:B WLC[182]:B
*.pininfo WLC[183]:B WLC[184]:B WLC[185]:B WLC[186]:B WLC[187]:B WLC[188]:B
*.pininfo WLC[189]:B WLC[190]:B WLC[191]:B WLC[192]:B WLC[193]:B WLC[194]:B
*.pininfo WLC[195]:B WLC[196]:B WLC[197]:B WLC[198]:B WLC[199]:B WLC[200]:B
*.pininfo WLC[201]:B WLC[202]:B WLC[203]:B WLC[204]:B WLC[205]:B WLC[206]:B
*.pininfo WLC[207]:B WLC[208]:B WLC[209]:B WLC[210]:B WLC[211]:B WLC[212]:B
*.pininfo WLC[213]:B WLC[214]:B WLC[215]:B WLC[216]:B WLC[217]:B WLC[218]:B
*.pininfo WLC[219]:B WLC[220]:B WLC[221]:B WLC[222]:B WLC[223]:B WLC[224]:B
*.pininfo WLC[225]:B WLC[226]:B WLC[227]:B WLC[228]:B WLC[229]:B WLC[230]:B
*.pininfo WLC[231]:B WLC[232]:B WLC[233]:B WLC[234]:B WLC[235]:B WLC[236]:B
*.pininfo WLC[237]:B WLC[238]:B WLC[239]:B WLC[240]:B WLC[241]:B WLC[242]:B
*.pininfo WLC[243]:B WLC[244]:B WLC[245]:B WLC[246]:B WLC[247]:B WLC[248]:B
*.pininfo WLC[249]:B WLC[250]:B WLC[251]:B WLC[252]:B WLC[253]:B WLC[254]:B
*.pininfo WLC[255]:B VNW:B PWR:B
XXSBNK_BITARY_R VSS VDDA PD[0] PD[1] PD[2] PD[3] WLC[0] WLC[1] WLC[2] WLC[3]
+ WLC[4] WLC[5] WLC[6] WLC[7] WLC[8] WLC[9] WLC[10] WLC[11] WLC[12] WLC[13]
+ WLC[14] WLC[15] WLC[16] WLC[17] WLC[18] WLC[19] WLC[20] WLC[21] WLC[22]
+ WLC[23] WLC[24] WLC[25] WLC[26] WLC[27] WLC[28] WLC[29] WLC[30] WLC[31]
+ WLC[32] WLC[33] WLC[34] WLC[35] WLC[36] WLC[37] WLC[38] WLC[39] WLC[40]
+ WLC[41] WLC[42] WLC[43] WLC[44] WLC[45] WLC[46] WLC[47] WLC[48] WLC[49]
+ WLC[50] WLC[51] WLC[52] WLC[53] WLC[54] WLC[55] WLC[56] WLC[57] WLC[58]
+ WLC[59] WLC[60] WLC[61] WLC[62] WLC[63] WLC[64] WLC[65] WLC[66] WLC[67]
+ WLC[68] WLC[69] WLC[70] WLC[71] WLC[72] WLC[73] WLC[74] WLC[75] WLC[76]
+ WLC[77] WLC[78] WLC[79] WLC[80] WLC[81] WLC[82] WLC[83] WLC[84] WLC[85]
+ WLC[86] WLC[87] WLC[88] WLC[89] WLC[90] WLC[91] WLC[92] WLC[93] WLC[94]
+ WLC[95] WLC[96] WLC[97] WLC[98] WLC[99] WLC[100] WLC[101] WLC[102] WLC[103]
+ WLC[104] WLC[105] WLC[106] WLC[107] WLC[108] WLC[109] WLC[110] WLC[111]
+ WLC[112] WLC[113] WLC[114] WLC[115] WLC[116] WLC[117] WLC[118] WLC[119]
+ WLC[120] WLC[121] WLC[122] WLC[123] WLC[124] WLC[125] WLC[126] WLC[127]
+ WLC[128] WLC[129] WLC[130] WLC[131] WLC[132] WLC[133] WLC[134] WLC[135]
+ WLC[136] WLC[137] WLC[138] WLC[139] WLC[140] WLC[141] WLC[142] WLC[143]
+ WLC[144] WLC[145] WLC[146] WLC[147] WLC[148] WLC[149] WLC[150] WLC[151]
+ WLC[152] WLC[153] WLC[154] WLC[155] WLC[156] WLC[157] WLC[158] WLC[159]
+ WLC[160] WLC[161] WLC[162] WLC[163] WLC[164] WLC[165] WLC[166] WLC[167]
+ WLC[168] WLC[169] WLC[170] WLC[171] WLC[172] WLC[173] WLC[174] WLC[175]
+ WLC[176] WLC[177] WLC[178] WLC[179] WLC[180] WLC[181] WLC[182] WLC[183]
+ WLC[184] WLC[185] WLC[186] WLC[187] WLC[188] WLC[189] WLC[190] WLC[191]
+ WLC[192] WLC[193] WLC[194] WLC[195] WLC[196] WLC[197] WLC[198] WLC[199]
+ WLC[200] WLC[201] WLC[202] WLC[203] WLC[204] WLC[205] WLC[206] WLC[207]
+ WLC[208] WLC[209] WLC[210] WLC[211] WLC[212] WLC[213] WLC[214] WLC[215]
+ WLC[216] WLC[217] WLC[218] WLC[219] WLC[220] WLC[221] WLC[222] WLC[223]
+ WLC[224] WLC[225] WLC[226] WLC[227] WLC[228] WLC[229] WLC[230] WLC[231]
+ WLC[232] WLC[233] WLC[234] WLC[235] WLC[236] WLC[237] WLC[238] WLC[239]
+ WLC[240] WLC[241] WLC[242] WLC[243] WLC[244] WLC[245] WLC[246] WLC[247]
+ WLC[248] WLC[249] WLC[250] WLC[251] WLC[252] WLC[253] WLC[254] WLC[255] VNW
+ PWR BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+ BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30]
+ BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+ BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50]
+ BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+ BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70]
+ BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80]
+ BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90]
+ BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100]
+ BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109]
+ BB[110] BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118]
+ BB[119] BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127]
+ BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11]
+ BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21]
+ BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31]
+ BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41]
+ BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51]
+ BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61]
+ BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71]
+ BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81]
+ BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91]
+ BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101]
+ BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110]
+ BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117] BT[118] BT[119]
+ BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126] BT[127] GBW[0]
+ GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3]
+ GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5]
+ GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] VSSX DBL
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX PD[3] PD[3] PD[3] PD[3] PD[3] PD[3]
+ PD[3] PD[3] PD[2] PD[2] PD[2] PD[2] PD[1] PD[1] PD[0] PD[0] RWL
+ spram_4096x16m16b1pm2re1RE1M16_B1BOT m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_R

.subckt spram_4096x16m16b1pm2re1RE1M16_B1XDXDEC_ARY CSH_ENB GRST BPUI SPUI
+ ZRR VSB[1] VSB[2] VSB[3] VSB[4] VNW XARMSBA[0] XARMSBA[1] XARMSBA[2]
+ XARMSBA[3] DBL1 WM[0] WM[1] WM[2] XARMSBB[0] XARMSBB[1] XARMSBB[2]
+ XARMSBB[3] LCLKB PWR LXWB[0] LXWB[1] LXWB[2] LXWB[3] ag_ctrl CSH_RR EN ENB
+ RM[0] RM[1] RM[2] T1EN QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+ QT[10] QT[11] QT[12] QT[13] CSH_LD XARLSBA[0] XARLSBA[1] XARLSBA[2]
+ XARLSBA[3] RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] VDDA VSS WLC[0]
+ WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6] WLC[7] WLC[8] WLC[9] WLC[10]
+ WLC[11] WLC[12] WLC[13] WLC[14] WLC[15] WLC[16] WLC[17] WLC[18] WLC[19]
+ WLC[20] WLC[21] WLC[22] WLC[23] WLC[24] WLC[25] WLC[26] WLC[27] WLC[28]
+ WLC[29] WLC[30] WLC[31] WLC[32] WLC[33] WLC[34] WLC[35] WLC[36] WLC[37]
+ WLC[38] WLC[39] WLC[40] WLC[41] WLC[42] WLC[43] WLC[44] WLC[45] WLC[46]
+ WLC[47] WLC[48] WLC[49] WLC[50] WLC[51] WLC[52] WLC[53] WLC[54] WLC[55]
+ WLC[56] WLC[57] WLC[58] WLC[59] WLC[60] WLC[61] WLC[62] WLC[63] WLC[64]
+ WLC[65] WLC[66] WLC[67] WLC[68] WLC[69] WLC[70] WLC[71] WLC[72] WLC[73]
+ WLC[74] WLC[75] WLC[76] WLC[77] WLC[78] WLC[79] WLC[80] WLC[81] WLC[82]
+ WLC[83] WLC[84] WLC[85] WLC[86] WLC[87] WLC[88] WLC[89] WLC[90] WLC[91]
+ WLC[92] WLC[93] WLC[94] WLC[95] WLC[96] WLC[97] WLC[98] WLC[99] WLC[100]
+ WLC[101] WLC[102] WLC[103] WLC[104] WLC[105] WLC[106] WLC[107] WLC[108]
+ WLC[109] WLC[110] WLC[111] WLC[112] WLC[113] WLC[114] WLC[115] WLC[116]
+ WLC[117] WLC[118] WLC[119] WLC[120] WLC[121] WLC[122] WLC[123] WLC[124]
+ WLC[125] WLC[126] WLC[127] WLC[128] WLC[129] WLC[130] WLC[131] WLC[132]
+ WLC[133] WLC[134] WLC[135] WLC[136] WLC[137] WLC[138] WLC[139] WLC[140]
+ WLC[141] WLC[142] WLC[143] WLC[144] WLC[145] WLC[146] WLC[147] WLC[148]
+ WLC[149] WLC[150] WLC[151] WLC[152] WLC[153] WLC[154] WLC[155] WLC[156]
+ WLC[157] WLC[158] WLC[159] WLC[160] WLC[161] WLC[162] WLC[163] WLC[164]
+ WLC[165] WLC[166] WLC[167] WLC[168] WLC[169] WLC[170] WLC[171] WLC[172]
+ WLC[173] WLC[174] WLC[175] WLC[176] WLC[177] WLC[178] WLC[179] WLC[180]
+ WLC[181] WLC[182] WLC[183] WLC[184] WLC[185] WLC[186] WLC[187] WLC[188]
+ WLC[189] WLC[190] WLC[191] WLC[192] WLC[193] WLC[194] WLC[195] WLC[196]
+ WLC[197] WLC[198] WLC[199] WLC[200] WLC[201] WLC[202] WLC[203] WLC[204]
+ WLC[205] WLC[206] WLC[207] WLC[208] WLC[209] WLC[210] WLC[211] WLC[212]
+ WLC[213] WLC[214] WLC[215] WLC[216] WLC[217] WLC[218] WLC[219] WLC[220]
+ WLC[221] WLC[222] WLC[223] WLC[224] WLC[225] WLC[226] WLC[227] WLC[228]
+ WLC[229] WLC[230] WLC[231] WLC[232] WLC[233] WLC[234] WLC[235] WLC[236]
+ WLC[237] WLC[238] WLC[239] WLC[240] WLC[241] WLC[242] WLC[243] WLC[244]
+ WLC[245] WLC[246] WLC[247] WLC[248] WLC[249] WLC[250] WLC[251] WLC[252]
+ WLC[253] WLC[254] WLC[255] VSSX PD[0] PD[1] PD[2] PD[3] RWL RWLD DBL
*.pininfo CSH_ENB:B GRST:B BPUI:B SPUI:B ZRR:B VSB[1]:B VSB[2]:B VSB[3]:B
*.pininfo VSB[4]:B VNW:B XARMSBA[0]:B XARMSBA[1]:B XARMSBA[2]:B XARMSBA[3]:B
*.pininfo DBL1:B WM[0]:B WM[1]:B WM[2]:B XARMSBB[0]:B XARMSBB[1]:B
*.pininfo XARMSBB[2]:B XARMSBB[3]:B LCLKB:B PWR:B LXWB[0]:B LXWB[1]:B
*.pininfo LXWB[2]:B LXWB[3]:B ag_ctrl:B CSH_RR:B EN:B ENB:B RM[0]:B RM[1]:B
*.pininfo RM[2]:B T1EN:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B
*.pininfo QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B CSH_LD:B
*.pininfo XARLSBA[0]:B XARLSBA[1]:B XARLSBA[2]:B XARLSBA[3]:B RWOUT:B
*.pininfo CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B VDDA:B VSS:B
*.pininfo WLC[0]:B WLC[1]:B WLC[2]:B WLC[3]:B WLC[4]:B WLC[5]:B WLC[6]:B
*.pininfo WLC[7]:B WLC[8]:B WLC[9]:B WLC[10]:B WLC[11]:B WLC[12]:B WLC[13]:B
*.pininfo WLC[14]:B WLC[15]:B WLC[16]:B WLC[17]:B WLC[18]:B WLC[19]:B
*.pininfo WLC[20]:B WLC[21]:B WLC[22]:B WLC[23]:B WLC[24]:B WLC[25]:B
*.pininfo WLC[26]:B WLC[27]:B WLC[28]:B WLC[29]:B WLC[30]:B WLC[31]:B
*.pininfo WLC[32]:B WLC[33]:B WLC[34]:B WLC[35]:B WLC[36]:B WLC[37]:B
*.pininfo WLC[38]:B WLC[39]:B WLC[40]:B WLC[41]:B WLC[42]:B WLC[43]:B
*.pininfo WLC[44]:B WLC[45]:B WLC[46]:B WLC[47]:B WLC[48]:B WLC[49]:B
*.pininfo WLC[50]:B WLC[51]:B WLC[52]:B WLC[53]:B WLC[54]:B WLC[55]:B
*.pininfo WLC[56]:B WLC[57]:B WLC[58]:B WLC[59]:B WLC[60]:B WLC[61]:B
*.pininfo WLC[62]:B WLC[63]:B WLC[64]:B WLC[65]:B WLC[66]:B WLC[67]:B
*.pininfo WLC[68]:B WLC[69]:B WLC[70]:B WLC[71]:B WLC[72]:B WLC[73]:B
*.pininfo WLC[74]:B WLC[75]:B WLC[76]:B WLC[77]:B WLC[78]:B WLC[79]:B
*.pininfo WLC[80]:B WLC[81]:B WLC[82]:B WLC[83]:B WLC[84]:B WLC[85]:B
*.pininfo WLC[86]:B WLC[87]:B WLC[88]:B WLC[89]:B WLC[90]:B WLC[91]:B
*.pininfo WLC[92]:B WLC[93]:B WLC[94]:B WLC[95]:B WLC[96]:B WLC[97]:B
*.pininfo WLC[98]:B WLC[99]:B WLC[100]:B WLC[101]:B WLC[102]:B WLC[103]:B
*.pininfo WLC[104]:B WLC[105]:B WLC[106]:B WLC[107]:B WLC[108]:B WLC[109]:B
*.pininfo WLC[110]:B WLC[111]:B WLC[112]:B WLC[113]:B WLC[114]:B WLC[115]:B
*.pininfo WLC[116]:B WLC[117]:B WLC[118]:B WLC[119]:B WLC[120]:B WLC[121]:B
*.pininfo WLC[122]:B WLC[123]:B WLC[124]:B WLC[125]:B WLC[126]:B WLC[127]:B
*.pininfo WLC[128]:B WLC[129]:B WLC[130]:B WLC[131]:B WLC[132]:B WLC[133]:B
*.pininfo WLC[134]:B WLC[135]:B WLC[136]:B WLC[137]:B WLC[138]:B WLC[139]:B
*.pininfo WLC[140]:B WLC[141]:B WLC[142]:B WLC[143]:B WLC[144]:B WLC[145]:B
*.pininfo WLC[146]:B WLC[147]:B WLC[148]:B WLC[149]:B WLC[150]:B WLC[151]:B
*.pininfo WLC[152]:B WLC[153]:B WLC[154]:B WLC[155]:B WLC[156]:B WLC[157]:B
*.pininfo WLC[158]:B WLC[159]:B WLC[160]:B WLC[161]:B WLC[162]:B WLC[163]:B
*.pininfo WLC[164]:B WLC[165]:B WLC[166]:B WLC[167]:B WLC[168]:B WLC[169]:B
*.pininfo WLC[170]:B WLC[171]:B WLC[172]:B WLC[173]:B WLC[174]:B WLC[175]:B
*.pininfo WLC[176]:B WLC[177]:B WLC[178]:B WLC[179]:B WLC[180]:B WLC[181]:B
*.pininfo WLC[182]:B WLC[183]:B WLC[184]:B WLC[185]:B WLC[186]:B WLC[187]:B
*.pininfo WLC[188]:B WLC[189]:B WLC[190]:B WLC[191]:B WLC[192]:B WLC[193]:B
*.pininfo WLC[194]:B WLC[195]:B WLC[196]:B WLC[197]:B WLC[198]:B WLC[199]:B
*.pininfo WLC[200]:B WLC[201]:B WLC[202]:B WLC[203]:B WLC[204]:B WLC[205]:B
*.pininfo WLC[206]:B WLC[207]:B WLC[208]:B WLC[209]:B WLC[210]:B WLC[211]:B
*.pininfo WLC[212]:B WLC[213]:B WLC[214]:B WLC[215]:B WLC[216]:B WLC[217]:B
*.pininfo WLC[218]:B WLC[219]:B WLC[220]:B WLC[221]:B WLC[222]:B WLC[223]:B
*.pininfo WLC[224]:B WLC[225]:B WLC[226]:B WLC[227]:B WLC[228]:B WLC[229]:B
*.pininfo WLC[230]:B WLC[231]:B WLC[232]:B WLC[233]:B WLC[234]:B WLC[235]:B
*.pininfo WLC[236]:B WLC[237]:B WLC[238]:B WLC[239]:B WLC[240]:B WLC[241]:B
*.pininfo WLC[242]:B WLC[243]:B WLC[244]:B WLC[245]:B WLC[246]:B WLC[247]:B
*.pininfo WLC[248]:B WLC[249]:B WLC[250]:B WLC[251]:B WLC[252]:B WLC[253]:B
*.pininfo WLC[254]:B WLC[255]:B VSSX:B PD[0]:B PD[1]:B PD[2]:B PD[3]:B RWL:B
*.pininfo RWLD:B DBL:B
XXc1r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[0] WLC[1]
+ WLC[2] WLC[3] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[0] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc2r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[4] WLC[5]
+ WLC[6] WLC[7] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[0] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc3r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[8] WLC[9]
+ WLC[10] WLC[11] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[0] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc4r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[12] WLC[13]
+ WLC[14] WLC[15] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[0] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc5r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[16] WLC[17]
+ WLC[18] WLC[19] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[1] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc6r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[20] WLC[21]
+ WLC[22] WLC[23] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[1] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc7r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[24] WLC[25]
+ WLC[26] WLC[27] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[1] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc8r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[28] WLC[29]
+ WLC[30] WLC[31] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[1] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc9r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[32] WLC[33]
+ WLC[34] WLC[35] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[2] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc10r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[36] WLC[37]
+ WLC[38] WLC[39] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[2] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc11r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[40] WLC[41]
+ WLC[42] WLC[43] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[2] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc12r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[44] WLC[45]
+ WLC[46] WLC[47] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[2] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc13r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[48] WLC[49]
+ WLC[50] WLC[51] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[3] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc14r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[52] WLC[53]
+ WLC[54] WLC[55] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[3] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc15r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[56] WLC[57]
+ WLC[58] WLC[59] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[3] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc16r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[60] WLC[61]
+ WLC[62] WLC[63] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[3] XARMSBB[0] ZRR
+ ag_ctrl xdec m=1
XXc17r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[64] WLC[65]
+ WLC[66] WLC[67] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[0] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc18r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[68] WLC[69]
+ WLC[70] WLC[71] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[0] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc19r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[72] WLC[73]
+ WLC[74] WLC[75] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[0] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc20r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[76] WLC[77]
+ WLC[78] WLC[79] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[0] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc21r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[80] WLC[81]
+ WLC[82] WLC[83] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[1] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc22r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[84] WLC[85]
+ WLC[86] WLC[87] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[1] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc23r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[88] WLC[89]
+ WLC[90] WLC[91] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[1] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc24r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[92] WLC[93]
+ WLC[94] WLC[95] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[1] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc25r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[96] WLC[97]
+ WLC[98] WLC[99] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[2] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc26r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[100] WLC[101]
+ WLC[102] WLC[103] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[2] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc27r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[104] WLC[105]
+ WLC[106] WLC[107] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[2] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc28r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[108] WLC[109]
+ WLC[110] WLC[111] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[2] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc29r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[112] WLC[113]
+ WLC[114] WLC[115] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[3] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc30r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[116] WLC[117]
+ WLC[118] WLC[119] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[3] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc31r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[120] WLC[121]
+ WLC[122] WLC[123] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[3] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc32r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[124] WLC[125]
+ WLC[126] WLC[127] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[3] XARMSBB[1] ZRR
+ ag_ctrl xdec m=1
XXc33r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[128] WLC[129]
+ WLC[130] WLC[131] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[0] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc34r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[132] WLC[133]
+ WLC[134] WLC[135] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[0] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc35r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[136] WLC[137]
+ WLC[138] WLC[139] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[0] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc36r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[140] WLC[141]
+ WLC[142] WLC[143] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[0] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc37r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[144] WLC[145]
+ WLC[146] WLC[147] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[1] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc38r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[148] WLC[149]
+ WLC[150] WLC[151] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[1] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc39r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[152] WLC[153]
+ WLC[154] WLC[155] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[1] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc40r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[156] WLC[157]
+ WLC[158] WLC[159] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[1] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc41r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[160] WLC[161]
+ WLC[162] WLC[163] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[2] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc42r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[164] WLC[165]
+ WLC[166] WLC[167] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[2] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc43r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[168] WLC[169]
+ WLC[170] WLC[171] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[2] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc44r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[172] WLC[173]
+ WLC[174] WLC[175] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[2] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc45r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[176] WLC[177]
+ WLC[178] WLC[179] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[3] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc46r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[180] WLC[181]
+ WLC[182] WLC[183] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[3] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc47r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[184] WLC[185]
+ WLC[186] WLC[187] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[3] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc48r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[188] WLC[189]
+ WLC[190] WLC[191] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[3] XARMSBB[2] ZRR
+ ag_ctrl xdec m=1
XXc49r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[192] WLC[193]
+ WLC[194] WLC[195] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[0] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc50r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[196] WLC[197]
+ WLC[198] WLC[199] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[0] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc51r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[200] WLC[201]
+ WLC[202] WLC[203] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[0] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc52r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[204] WLC[205]
+ WLC[206] WLC[207] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[0] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc53r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[208] WLC[209]
+ WLC[210] WLC[211] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[1] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc54r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[212] WLC[213]
+ WLC[214] WLC[215] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[1] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc55r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[216] WLC[217]
+ WLC[218] WLC[219] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[1] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc56r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[220] WLC[221]
+ WLC[222] WLC[223] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[1] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc57r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[224] WLC[225]
+ WLC[226] WLC[227] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[2] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc58r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[228] WLC[229]
+ WLC[230] WLC[231] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[2] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc59r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[232] WLC[233]
+ WLC[234] WLC[235] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[2] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc60r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[236] WLC[237]
+ WLC[238] WLC[239] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[2] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc61r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[240] WLC[241]
+ WLC[242] WLC[243] WM[0] WM[1] WM[2] XARLSBA[0] XARMSBA[3] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc62r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[244] WLC[245]
+ WLC[246] WLC[247] WM[0] WM[1] WM[2] XARLSBA[1] XARMSBA[3] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc63r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[248] WLC[249]
+ WLC[250] WLC[251] WM[0] WM[1] WM[2] XARLSBA[2] XARMSBA[3] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc64r0 BPUI CSH_ENB CSH_LD CSH_RR CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ DBL1 EN ENB GRST LCLKB XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3]
+ XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0] XARMSBB[1]
+ XARMSBB[2] XARMSBB[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] PWR QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2]
+ RWOUT SPUI T1EN VDDA VNW VSB[1] VSB[2] VSB[3] VSB[4] VSS WLC[252] WLC[253]
+ WLC[254] WLC[255] WM[0] WM[1] WM[2] XARLSBA[3] XARMSBA[3] XARMSBB[3] ZRR
+ ag_ctrl xdec m=1
XXc65r0 BPUI CSH_ENB CSH_LD CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] DBL DBL1
+ EN ENB LCLKB PD[0] PD[1] PD[2] PD[3] PWR QT[2] QT[3] QT[4] QT[5] QT[6]
+ QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RM[0] RM[1] RM[2] RWL RWLD
+ RWOUT SPUI T1EN VDDA VNW VSS VSSX WM[0] WM[1] WM[2] ag_ctrl
+ local_tmr_bitcell1 m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1XDXDEC_ARY

.subckt spram_4096x16m16b1pm2re1RE1M16_B1XD VNW PWR VDDA VSS WLC[0] WLC[1]
+ WLC[2] WLC[3] WLC[4] WLC[5] WLC[6] WLC[7] WLC[8] WLC[9] WLC[10] WLC[11]
+ WLC[12] WLC[13] WLC[14] WLC[15] WLC[16] WLC[17] WLC[18] WLC[19] WLC[20]
+ WLC[21] WLC[22] WLC[23] WLC[24] WLC[25] WLC[26] WLC[27] WLC[28] WLC[29]
+ WLC[30] WLC[31] WLC[32] WLC[33] WLC[34] WLC[35] WLC[36] WLC[37] WLC[38]
+ WLC[39] WLC[40] WLC[41] WLC[42] WLC[43] WLC[44] WLC[45] WLC[46] WLC[47]
+ WLC[48] WLC[49] WLC[50] WLC[51] WLC[52] WLC[53] WLC[54] WLC[55] WLC[56]
+ WLC[57] WLC[58] WLC[59] WLC[60] WLC[61] WLC[62] WLC[63] WLC[64] WLC[65]
+ WLC[66] WLC[67] WLC[68] WLC[69] WLC[70] WLC[71] WLC[72] WLC[73] WLC[74]
+ WLC[75] WLC[76] WLC[77] WLC[78] WLC[79] WLC[80] WLC[81] WLC[82] WLC[83]
+ WLC[84] WLC[85] WLC[86] WLC[87] WLC[88] WLC[89] WLC[90] WLC[91] WLC[92]
+ WLC[93] WLC[94] WLC[95] WLC[96] WLC[97] WLC[98] WLC[99] WLC[100] WLC[101]
+ WLC[102] WLC[103] WLC[104] WLC[105] WLC[106] WLC[107] WLC[108] WLC[109]
+ WLC[110] WLC[111] WLC[112] WLC[113] WLC[114] WLC[115] WLC[116] WLC[117]
+ WLC[118] WLC[119] WLC[120] WLC[121] WLC[122] WLC[123] WLC[124] WLC[125]
+ WLC[126] WLC[127] WLC[128] WLC[129] WLC[130] WLC[131] WLC[132] WLC[133]
+ WLC[134] WLC[135] WLC[136] WLC[137] WLC[138] WLC[139] WLC[140] WLC[141]
+ WLC[142] WLC[143] WLC[144] WLC[145] WLC[146] WLC[147] WLC[148] WLC[149]
+ WLC[150] WLC[151] WLC[152] WLC[153] WLC[154] WLC[155] WLC[156] WLC[157]
+ WLC[158] WLC[159] WLC[160] WLC[161] WLC[162] WLC[163] WLC[164] WLC[165]
+ WLC[166] WLC[167] WLC[168] WLC[169] WLC[170] WLC[171] WLC[172] WLC[173]
+ WLC[174] WLC[175] WLC[176] WLC[177] WLC[178] WLC[179] WLC[180] WLC[181]
+ WLC[182] WLC[183] WLC[184] WLC[185] WLC[186] WLC[187] WLC[188] WLC[189]
+ WLC[190] WLC[191] WLC[192] WLC[193] WLC[194] WLC[195] WLC[196] WLC[197]
+ WLC[198] WLC[199] WLC[200] WLC[201] WLC[202] WLC[203] WLC[204] WLC[205]
+ WLC[206] WLC[207] WLC[208] WLC[209] WLC[210] WLC[211] WLC[212] WLC[213]
+ WLC[214] WLC[215] WLC[216] WLC[217] WLC[218] WLC[219] WLC[220] WLC[221]
+ WLC[222] WLC[223] WLC[224] WLC[225] WLC[226] WLC[227] WLC[228] WLC[229]
+ WLC[230] WLC[231] WLC[232] WLC[233] WLC[234] WLC[235] WLC[236] WLC[237]
+ WLC[238] WLC[239] WLC[240] WLC[241] WLC[242] WLC[243] WLC[244] WLC[245]
+ WLC[246] WLC[247] WLC[248] WLC[249] WLC[250] WLC[251] WLC[252] WLC[253]
+ WLC[254] WLC[255] PD[0] PD[1] PD[2] PD[3] RWL RWLD DBL CSH_ENB GRST BPUI
+ SPUI ZRR VSB[0] VSB[1] VSB[2] VSB[3] XARMSBA[0] XARMSBA[1] XARMSBA[2]
+ XARMSBA[3] DBL0 WM[0] WM[1] WM[2] XARMSBB[0] XARMSBB[1] XARMSBB[2]
+ XARMSBB[3] LCLKB LXWB[0] LXWB[1] LXWB[2] LXWB[3] ag_ctrl CSH_RR EN ENB
+ RM[0] RM[1] RM[2] T0EN QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+ QT[8] QT[9] QT[10] QT[11] CSH_LD XARLSBA[0] XARLSBA[1] XARLSBA[2]
+ XARLSBA[3] RWOUT CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] VSSX
*.pininfo VNW:B PWR:B VDDA:B VSS:B WLC[0]:B WLC[1]:B WLC[2]:B WLC[3]:B
*.pininfo WLC[4]:B WLC[5]:B WLC[6]:B WLC[7]:B WLC[8]:B WLC[9]:B WLC[10]:B
*.pininfo WLC[11]:B WLC[12]:B WLC[13]:B WLC[14]:B WLC[15]:B WLC[16]:B
*.pininfo WLC[17]:B WLC[18]:B WLC[19]:B WLC[20]:B WLC[21]:B WLC[22]:B
*.pininfo WLC[23]:B WLC[24]:B WLC[25]:B WLC[26]:B WLC[27]:B WLC[28]:B
*.pininfo WLC[29]:B WLC[30]:B WLC[31]:B WLC[32]:B WLC[33]:B WLC[34]:B
*.pininfo WLC[35]:B WLC[36]:B WLC[37]:B WLC[38]:B WLC[39]:B WLC[40]:B
*.pininfo WLC[41]:B WLC[42]:B WLC[43]:B WLC[44]:B WLC[45]:B WLC[46]:B
*.pininfo WLC[47]:B WLC[48]:B WLC[49]:B WLC[50]:B WLC[51]:B WLC[52]:B
*.pininfo WLC[53]:B WLC[54]:B WLC[55]:B WLC[56]:B WLC[57]:B WLC[58]:B
*.pininfo WLC[59]:B WLC[60]:B WLC[61]:B WLC[62]:B WLC[63]:B WLC[64]:B
*.pininfo WLC[65]:B WLC[66]:B WLC[67]:B WLC[68]:B WLC[69]:B WLC[70]:B
*.pininfo WLC[71]:B WLC[72]:B WLC[73]:B WLC[74]:B WLC[75]:B WLC[76]:B
*.pininfo WLC[77]:B WLC[78]:B WLC[79]:B WLC[80]:B WLC[81]:B WLC[82]:B
*.pininfo WLC[83]:B WLC[84]:B WLC[85]:B WLC[86]:B WLC[87]:B WLC[88]:B
*.pininfo WLC[89]:B WLC[90]:B WLC[91]:B WLC[92]:B WLC[93]:B WLC[94]:B
*.pininfo WLC[95]:B WLC[96]:B WLC[97]:B WLC[98]:B WLC[99]:B WLC[100]:B
*.pininfo WLC[101]:B WLC[102]:B WLC[103]:B WLC[104]:B WLC[105]:B WLC[106]:B
*.pininfo WLC[107]:B WLC[108]:B WLC[109]:B WLC[110]:B WLC[111]:B WLC[112]:B
*.pininfo WLC[113]:B WLC[114]:B WLC[115]:B WLC[116]:B WLC[117]:B WLC[118]:B
*.pininfo WLC[119]:B WLC[120]:B WLC[121]:B WLC[122]:B WLC[123]:B WLC[124]:B
*.pininfo WLC[125]:B WLC[126]:B WLC[127]:B WLC[128]:B WLC[129]:B WLC[130]:B
*.pininfo WLC[131]:B WLC[132]:B WLC[133]:B WLC[134]:B WLC[135]:B WLC[136]:B
*.pininfo WLC[137]:B WLC[138]:B WLC[139]:B WLC[140]:B WLC[141]:B WLC[142]:B
*.pininfo WLC[143]:B WLC[144]:B WLC[145]:B WLC[146]:B WLC[147]:B WLC[148]:B
*.pininfo WLC[149]:B WLC[150]:B WLC[151]:B WLC[152]:B WLC[153]:B WLC[154]:B
*.pininfo WLC[155]:B WLC[156]:B WLC[157]:B WLC[158]:B WLC[159]:B WLC[160]:B
*.pininfo WLC[161]:B WLC[162]:B WLC[163]:B WLC[164]:B WLC[165]:B WLC[166]:B
*.pininfo WLC[167]:B WLC[168]:B WLC[169]:B WLC[170]:B WLC[171]:B WLC[172]:B
*.pininfo WLC[173]:B WLC[174]:B WLC[175]:B WLC[176]:B WLC[177]:B WLC[178]:B
*.pininfo WLC[179]:B WLC[180]:B WLC[181]:B WLC[182]:B WLC[183]:B WLC[184]:B
*.pininfo WLC[185]:B WLC[186]:B WLC[187]:B WLC[188]:B WLC[189]:B WLC[190]:B
*.pininfo WLC[191]:B WLC[192]:B WLC[193]:B WLC[194]:B WLC[195]:B WLC[196]:B
*.pininfo WLC[197]:B WLC[198]:B WLC[199]:B WLC[200]:B WLC[201]:B WLC[202]:B
*.pininfo WLC[203]:B WLC[204]:B WLC[205]:B WLC[206]:B WLC[207]:B WLC[208]:B
*.pininfo WLC[209]:B WLC[210]:B WLC[211]:B WLC[212]:B WLC[213]:B WLC[214]:B
*.pininfo WLC[215]:B WLC[216]:B WLC[217]:B WLC[218]:B WLC[219]:B WLC[220]:B
*.pininfo WLC[221]:B WLC[222]:B WLC[223]:B WLC[224]:B WLC[225]:B WLC[226]:B
*.pininfo WLC[227]:B WLC[228]:B WLC[229]:B WLC[230]:B WLC[231]:B WLC[232]:B
*.pininfo WLC[233]:B WLC[234]:B WLC[235]:B WLC[236]:B WLC[237]:B WLC[238]:B
*.pininfo WLC[239]:B WLC[240]:B WLC[241]:B WLC[242]:B WLC[243]:B WLC[244]:B
*.pininfo WLC[245]:B WLC[246]:B WLC[247]:B WLC[248]:B WLC[249]:B WLC[250]:B
*.pininfo WLC[251]:B WLC[252]:B WLC[253]:B WLC[254]:B WLC[255]:B PD[0]:B
*.pininfo PD[1]:B PD[2]:B PD[3]:B RWL:B RWLD:B DBL:B CSH_ENB:B GRST:B BPUI:B
*.pininfo SPUI:B ZRR:B VSB[0]:B VSB[1]:B VSB[2]:B VSB[3]:B XARMSBA[0]:B
*.pininfo XARMSBA[1]:B XARMSBA[2]:B XARMSBA[3]:B DBL0:B WM[0]:B WM[1]:B
*.pininfo WM[2]:B XARMSBB[0]:B XARMSBB[1]:B XARMSBB[2]:B XARMSBB[3]:B LCLKB:B
*.pininfo LXWB[0]:B LXWB[1]:B LXWB[2]:B LXWB[3]:B ag_ctrl:B CSH_RR:B EN:B
*.pininfo ENB:B RM[0]:B RM[1]:B RM[2]:B T0EN:B QT[0]:B QT[1]:B QT[2]:B
*.pininfo QT[3]:B QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B
*.pininfo QT[11]:B CSH_LD:B XARLSBA[0]:B XARLSBA[1]:B XARLSBA[2]:B
*.pininfo XARLSBA[3]:B RWOUT:B CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B
*.pininfo CSH_YS[3]:B VSSX:B
XXspram_4096x16m16b1pm2re1RE1M16_B1XDXDEC_ARY_0 CSH_ENB GRST BPUI SPUI ZRR
+ VSB[0] VSB[1] VSB[2] VSB[3] VNW XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3]
+ DBL0 WM[0] WM[1] WM[2] XARMSBB[0] XARMSBB[1] XARMSBB[2] XARMSBB[3] LCLKB
+ PWR LXWB[0] LXWB[1] LXWB[2] LXWB[3] ag_ctrl CSH_RR EN ENB RM[0] RM[1] RM[2]
+ T0EN QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+ QT[11] CSH_LD XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3] RWOUT CSH_YS[0]
+ CSH_YS[1] CSH_YS[2] CSH_YS[3] VDDA VSS WLC[0] WLC[1] WLC[2] WLC[3] WLC[4]
+ WLC[5] WLC[6] WLC[7] WLC[8] WLC[9] WLC[10] WLC[11] WLC[12] WLC[13] WLC[14]
+ WLC[15] WLC[16] WLC[17] WLC[18] WLC[19] WLC[20] WLC[21] WLC[22] WLC[23]
+ WLC[24] WLC[25] WLC[26] WLC[27] WLC[28] WLC[29] WLC[30] WLC[31] WLC[32]
+ WLC[33] WLC[34] WLC[35] WLC[36] WLC[37] WLC[38] WLC[39] WLC[40] WLC[41]
+ WLC[42] WLC[43] WLC[44] WLC[45] WLC[46] WLC[47] WLC[48] WLC[49] WLC[50]
+ WLC[51] WLC[52] WLC[53] WLC[54] WLC[55] WLC[56] WLC[57] WLC[58] WLC[59]
+ WLC[60] WLC[61] WLC[62] WLC[63] WLC[64] WLC[65] WLC[66] WLC[67] WLC[68]
+ WLC[69] WLC[70] WLC[71] WLC[72] WLC[73] WLC[74] WLC[75] WLC[76] WLC[77]
+ WLC[78] WLC[79] WLC[80] WLC[81] WLC[82] WLC[83] WLC[84] WLC[85] WLC[86]
+ WLC[87] WLC[88] WLC[89] WLC[90] WLC[91] WLC[92] WLC[93] WLC[94] WLC[95]
+ WLC[96] WLC[97] WLC[98] WLC[99] WLC[100] WLC[101] WLC[102] WLC[103]
+ WLC[104] WLC[105] WLC[106] WLC[107] WLC[108] WLC[109] WLC[110] WLC[111]
+ WLC[112] WLC[113] WLC[114] WLC[115] WLC[116] WLC[117] WLC[118] WLC[119]
+ WLC[120] WLC[121] WLC[122] WLC[123] WLC[124] WLC[125] WLC[126] WLC[127]
+ WLC[128] WLC[129] WLC[130] WLC[131] WLC[132] WLC[133] WLC[134] WLC[135]
+ WLC[136] WLC[137] WLC[138] WLC[139] WLC[140] WLC[141] WLC[142] WLC[143]
+ WLC[144] WLC[145] WLC[146] WLC[147] WLC[148] WLC[149] WLC[150] WLC[151]
+ WLC[152] WLC[153] WLC[154] WLC[155] WLC[156] WLC[157] WLC[158] WLC[159]
+ WLC[160] WLC[161] WLC[162] WLC[163] WLC[164] WLC[165] WLC[166] WLC[167]
+ WLC[168] WLC[169] WLC[170] WLC[171] WLC[172] WLC[173] WLC[174] WLC[175]
+ WLC[176] WLC[177] WLC[178] WLC[179] WLC[180] WLC[181] WLC[182] WLC[183]
+ WLC[184] WLC[185] WLC[186] WLC[187] WLC[188] WLC[189] WLC[190] WLC[191]
+ WLC[192] WLC[193] WLC[194] WLC[195] WLC[196] WLC[197] WLC[198] WLC[199]
+ WLC[200] WLC[201] WLC[202] WLC[203] WLC[204] WLC[205] WLC[206] WLC[207]
+ WLC[208] WLC[209] WLC[210] WLC[211] WLC[212] WLC[213] WLC[214] WLC[215]
+ WLC[216] WLC[217] WLC[218] WLC[219] WLC[220] WLC[221] WLC[222] WLC[223]
+ WLC[224] WLC[225] WLC[226] WLC[227] WLC[228] WLC[229] WLC[230] WLC[231]
+ WLC[232] WLC[233] WLC[234] WLC[235] WLC[236] WLC[237] WLC[238] WLC[239]
+ WLC[240] WLC[241] WLC[242] WLC[243] WLC[244] WLC[245] WLC[246] WLC[247]
+ WLC[248] WLC[249] WLC[250] WLC[251] WLC[252] WLC[253] WLC[254] WLC[255]
+ VSSX PD[0] PD[1] PD[2] PD[3] RWL RWLD DBL
+ spram_4096x16m16b1pm2re1RE1M16_B1XDXDEC_ARY m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1XD

.subckt spram_4096x16m16b1pm2re1RE1M16_B1SBNK_XDEC CSH_YS[0] CSH_YS[1]
+ CSH_YS[2] CSH_YS[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] QT[0] QT[1] QT[2] QT[3]
+ QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] RMO[0] RMO[1] RMO[2]
+ VSB[0] VSB[1] VSB[2] VSB[3] WMO[0] WMO[1] WMO[2] XARLSBA[0] XARLSBA[1]
+ XARLSBA[2] XARLSBA[3] XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3]
+ XARMSBB[0] XARMSBB[1] XARMSBB[2] XARMSBB[3] CSH_ENB BPUI SPUI ZRR VNW DBL0
+ LCLKB PWR ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT VSSX PD[0] PD[1] PD[2]
+ PD[3] WLC[0] WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6] WLC[7] WLC[8] WLC[9]
+ WLC[10] WLC[11] WLC[12] WLC[13] WLC[14] WLC[15] WLC[16] WLC[17] WLC[18]
+ WLC[19] WLC[20] WLC[21] WLC[22] WLC[23] WLC[24] WLC[25] WLC[26] WLC[27]
+ WLC[28] WLC[29] WLC[30] WLC[31] WLC[32] WLC[33] WLC[34] WLC[35] WLC[36]
+ WLC[37] WLC[38] WLC[39] WLC[40] WLC[41] WLC[42] WLC[43] WLC[44] WLC[45]
+ WLC[46] WLC[47] WLC[48] WLC[49] WLC[50] WLC[51] WLC[52] WLC[53] WLC[54]
+ WLC[55] WLC[56] WLC[57] WLC[58] WLC[59] WLC[60] WLC[61] WLC[62] WLC[63]
+ WLC[64] WLC[65] WLC[66] WLC[67] WLC[68] WLC[69] WLC[70] WLC[71] WLC[72]
+ WLC[73] WLC[74] WLC[75] WLC[76] WLC[77] WLC[78] WLC[79] WLC[80] WLC[81]
+ WLC[82] WLC[83] WLC[84] WLC[85] WLC[86] WLC[87] WLC[88] WLC[89] WLC[90]
+ WLC[91] WLC[92] WLC[93] WLC[94] WLC[95] WLC[96] WLC[97] WLC[98] WLC[99]
+ WLC[100] WLC[101] WLC[102] WLC[103] WLC[104] WLC[105] WLC[106] WLC[107]
+ WLC[108] WLC[109] WLC[110] WLC[111] WLC[112] WLC[113] WLC[114] WLC[115]
+ WLC[116] WLC[117] WLC[118] WLC[119] WLC[120] WLC[121] WLC[122] WLC[123]
+ WLC[124] WLC[125] WLC[126] WLC[127] WLC[128] WLC[129] WLC[130] WLC[131]
+ WLC[132] WLC[133] WLC[134] WLC[135] WLC[136] WLC[137] WLC[138] WLC[139]
+ WLC[140] WLC[141] WLC[142] WLC[143] WLC[144] WLC[145] WLC[146] WLC[147]
+ WLC[148] WLC[149] WLC[150] WLC[151] WLC[152] WLC[153] WLC[154] WLC[155]
+ WLC[156] WLC[157] WLC[158] WLC[159] WLC[160] WLC[161] WLC[162] WLC[163]
+ WLC[164] WLC[165] WLC[166] WLC[167] WLC[168] WLC[169] WLC[170] WLC[171]
+ WLC[172] WLC[173] WLC[174] WLC[175] WLC[176] WLC[177] WLC[178] WLC[179]
+ WLC[180] WLC[181] WLC[182] WLC[183] WLC[184] WLC[185] WLC[186] WLC[187]
+ WLC[188] WLC[189] WLC[190] WLC[191] WLC[192] WLC[193] WLC[194] WLC[195]
+ WLC[196] WLC[197] WLC[198] WLC[199] WLC[200] WLC[201] WLC[202] WLC[203]
+ WLC[204] WLC[205] WLC[206] WLC[207] WLC[208] WLC[209] WLC[210] WLC[211]
+ WLC[212] WLC[213] WLC[214] WLC[215] WLC[216] WLC[217] WLC[218] WLC[219]
+ WLC[220] WLC[221] WLC[222] WLC[223] WLC[224] WLC[225] WLC[226] WLC[227]
+ WLC[228] WLC[229] WLC[230] WLC[231] WLC[232] WLC[233] WLC[234] WLC[235]
+ WLC[236] WLC[237] WLC[238] WLC[239] WLC[240] WLC[241] WLC[242] WLC[243]
+ WLC[244] WLC[245] WLC[246] WLC[247] WLC[248] WLC[249] WLC[250] WLC[251]
+ WLC[252] WLC[253] WLC[254] WLC[255] VDDA VSS RWL DBL
*.pininfo CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B LXWB[0]:B LXWB[1]:B
*.pininfo LXWB[2]:B LXWB[3]:B QT[0]:B QT[1]:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B
*.pininfo QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B RMO[0]:B RMO[1]:B
*.pininfo RMO[2]:B VSB[0]:B VSB[1]:B VSB[2]:B VSB[3]:B WMO[0]:B WMO[1]:B
*.pininfo WMO[2]:B XARLSBA[0]:B XARLSBA[1]:B XARLSBA[2]:B XARLSBA[3]:B
*.pininfo XARMSBA[0]:B XARMSBA[1]:B XARMSBA[2]:B XARMSBA[3]:B XARMSBB[0]:B
*.pininfo XARMSBB[1]:B XARMSBB[2]:B XARMSBB[3]:B CSH_ENB:B BPUI:B SPUI:B
*.pininfo ZRR:B VNW:B DBL0:B LCLKB:B PWR:B ag_ctrl:B CSH_RR:B EN:B ENB:B
*.pininfo T0EN:B CSH_LD:B RWOUT:B VSSX:B PD[0]:B PD[1]:B PD[2]:B PD[3]:B
*.pininfo WLC[0]:B WLC[1]:B WLC[2]:B WLC[3]:B WLC[4]:B WLC[5]:B WLC[6]:B
*.pininfo WLC[7]:B WLC[8]:B WLC[9]:B WLC[10]:B WLC[11]:B WLC[12]:B WLC[13]:B
*.pininfo WLC[14]:B WLC[15]:B WLC[16]:B WLC[17]:B WLC[18]:B WLC[19]:B
*.pininfo WLC[20]:B WLC[21]:B WLC[22]:B WLC[23]:B WLC[24]:B WLC[25]:B
*.pininfo WLC[26]:B WLC[27]:B WLC[28]:B WLC[29]:B WLC[30]:B WLC[31]:B
*.pininfo WLC[32]:B WLC[33]:B WLC[34]:B WLC[35]:B WLC[36]:B WLC[37]:B
*.pininfo WLC[38]:B WLC[39]:B WLC[40]:B WLC[41]:B WLC[42]:B WLC[43]:B
*.pininfo WLC[44]:B WLC[45]:B WLC[46]:B WLC[47]:B WLC[48]:B WLC[49]:B
*.pininfo WLC[50]:B WLC[51]:B WLC[52]:B WLC[53]:B WLC[54]:B WLC[55]:B
*.pininfo WLC[56]:B WLC[57]:B WLC[58]:B WLC[59]:B WLC[60]:B WLC[61]:B
*.pininfo WLC[62]:B WLC[63]:B WLC[64]:B WLC[65]:B WLC[66]:B WLC[67]:B
*.pininfo WLC[68]:B WLC[69]:B WLC[70]:B WLC[71]:B WLC[72]:B WLC[73]:B
*.pininfo WLC[74]:B WLC[75]:B WLC[76]:B WLC[77]:B WLC[78]:B WLC[79]:B
*.pininfo WLC[80]:B WLC[81]:B WLC[82]:B WLC[83]:B WLC[84]:B WLC[85]:B
*.pininfo WLC[86]:B WLC[87]:B WLC[88]:B WLC[89]:B WLC[90]:B WLC[91]:B
*.pininfo WLC[92]:B WLC[93]:B WLC[94]:B WLC[95]:B WLC[96]:B WLC[97]:B
*.pininfo WLC[98]:B WLC[99]:B WLC[100]:B WLC[101]:B WLC[102]:B WLC[103]:B
*.pininfo WLC[104]:B WLC[105]:B WLC[106]:B WLC[107]:B WLC[108]:B WLC[109]:B
*.pininfo WLC[110]:B WLC[111]:B WLC[112]:B WLC[113]:B WLC[114]:B WLC[115]:B
*.pininfo WLC[116]:B WLC[117]:B WLC[118]:B WLC[119]:B WLC[120]:B WLC[121]:B
*.pininfo WLC[122]:B WLC[123]:B WLC[124]:B WLC[125]:B WLC[126]:B WLC[127]:B
*.pininfo WLC[128]:B WLC[129]:B WLC[130]:B WLC[131]:B WLC[132]:B WLC[133]:B
*.pininfo WLC[134]:B WLC[135]:B WLC[136]:B WLC[137]:B WLC[138]:B WLC[139]:B
*.pininfo WLC[140]:B WLC[141]:B WLC[142]:B WLC[143]:B WLC[144]:B WLC[145]:B
*.pininfo WLC[146]:B WLC[147]:B WLC[148]:B WLC[149]:B WLC[150]:B WLC[151]:B
*.pininfo WLC[152]:B WLC[153]:B WLC[154]:B WLC[155]:B WLC[156]:B WLC[157]:B
*.pininfo WLC[158]:B WLC[159]:B WLC[160]:B WLC[161]:B WLC[162]:B WLC[163]:B
*.pininfo WLC[164]:B WLC[165]:B WLC[166]:B WLC[167]:B WLC[168]:B WLC[169]:B
*.pininfo WLC[170]:B WLC[171]:B WLC[172]:B WLC[173]:B WLC[174]:B WLC[175]:B
*.pininfo WLC[176]:B WLC[177]:B WLC[178]:B WLC[179]:B WLC[180]:B WLC[181]:B
*.pininfo WLC[182]:B WLC[183]:B WLC[184]:B WLC[185]:B WLC[186]:B WLC[187]:B
*.pininfo WLC[188]:B WLC[189]:B WLC[190]:B WLC[191]:B WLC[192]:B WLC[193]:B
*.pininfo WLC[194]:B WLC[195]:B WLC[196]:B WLC[197]:B WLC[198]:B WLC[199]:B
*.pininfo WLC[200]:B WLC[201]:B WLC[202]:B WLC[203]:B WLC[204]:B WLC[205]:B
*.pininfo WLC[206]:B WLC[207]:B WLC[208]:B WLC[209]:B WLC[210]:B WLC[211]:B
*.pininfo WLC[212]:B WLC[213]:B WLC[214]:B WLC[215]:B WLC[216]:B WLC[217]:B
*.pininfo WLC[218]:B WLC[219]:B WLC[220]:B WLC[221]:B WLC[222]:B WLC[223]:B
*.pininfo WLC[224]:B WLC[225]:B WLC[226]:B WLC[227]:B WLC[228]:B WLC[229]:B
*.pininfo WLC[230]:B WLC[231]:B WLC[232]:B WLC[233]:B WLC[234]:B WLC[235]:B
*.pininfo WLC[236]:B WLC[237]:B WLC[238]:B WLC[239]:B WLC[240]:B WLC[241]:B
*.pininfo WLC[242]:B WLC[243]:B WLC[244]:B WLC[245]:B WLC[246]:B WLC[247]:B
*.pininfo WLC[248]:B WLC[249]:B WLC[250]:B WLC[251]:B WLC[252]:B WLC[253]:B
*.pininfo WLC[254]:B WLC[255]:B VDDA:B VSS:B RWL:B DBL:B
XXSBNK_XDEC VNW PWR VDDA VSS WLC[0] WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6]
+ WLC[7] WLC[8] WLC[9] WLC[10] WLC[11] WLC[12] WLC[13] WLC[14] WLC[15]
+ WLC[16] WLC[17] WLC[18] WLC[19] WLC[20] WLC[21] WLC[22] WLC[23] WLC[24]
+ WLC[25] WLC[26] WLC[27] WLC[28] WLC[29] WLC[30] WLC[31] WLC[32] WLC[33]
+ WLC[34] WLC[35] WLC[36] WLC[37] WLC[38] WLC[39] WLC[40] WLC[41] WLC[42]
+ WLC[43] WLC[44] WLC[45] WLC[46] WLC[47] WLC[48] WLC[49] WLC[50] WLC[51]
+ WLC[52] WLC[53] WLC[54] WLC[55] WLC[56] WLC[57] WLC[58] WLC[59] WLC[60]
+ WLC[61] WLC[62] WLC[63] WLC[64] WLC[65] WLC[66] WLC[67] WLC[68] WLC[69]
+ WLC[70] WLC[71] WLC[72] WLC[73] WLC[74] WLC[75] WLC[76] WLC[77] WLC[78]
+ WLC[79] WLC[80] WLC[81] WLC[82] WLC[83] WLC[84] WLC[85] WLC[86] WLC[87]
+ WLC[88] WLC[89] WLC[90] WLC[91] WLC[92] WLC[93] WLC[94] WLC[95] WLC[96]
+ WLC[97] WLC[98] WLC[99] WLC[100] WLC[101] WLC[102] WLC[103] WLC[104]
+ WLC[105] WLC[106] WLC[107] WLC[108] WLC[109] WLC[110] WLC[111] WLC[112]
+ WLC[113] WLC[114] WLC[115] WLC[116] WLC[117] WLC[118] WLC[119] WLC[120]
+ WLC[121] WLC[122] WLC[123] WLC[124] WLC[125] WLC[126] WLC[127] WLC[128]
+ WLC[129] WLC[130] WLC[131] WLC[132] WLC[133] WLC[134] WLC[135] WLC[136]
+ WLC[137] WLC[138] WLC[139] WLC[140] WLC[141] WLC[142] WLC[143] WLC[144]
+ WLC[145] WLC[146] WLC[147] WLC[148] WLC[149] WLC[150] WLC[151] WLC[152]
+ WLC[153] WLC[154] WLC[155] WLC[156] WLC[157] WLC[158] WLC[159] WLC[160]
+ WLC[161] WLC[162] WLC[163] WLC[164] WLC[165] WLC[166] WLC[167] WLC[168]
+ WLC[169] WLC[170] WLC[171] WLC[172] WLC[173] WLC[174] WLC[175] WLC[176]
+ WLC[177] WLC[178] WLC[179] WLC[180] WLC[181] WLC[182] WLC[183] WLC[184]
+ WLC[185] WLC[186] WLC[187] WLC[188] WLC[189] WLC[190] WLC[191] WLC[192]
+ WLC[193] WLC[194] WLC[195] WLC[196] WLC[197] WLC[198] WLC[199] WLC[200]
+ WLC[201] WLC[202] WLC[203] WLC[204] WLC[205] WLC[206] WLC[207] WLC[208]
+ WLC[209] WLC[210] WLC[211] WLC[212] WLC[213] WLC[214] WLC[215] WLC[216]
+ WLC[217] WLC[218] WLC[219] WLC[220] WLC[221] WLC[222] WLC[223] WLC[224]
+ WLC[225] WLC[226] WLC[227] WLC[228] WLC[229] WLC[230] WLC[231] WLC[232]
+ WLC[233] WLC[234] WLC[235] WLC[236] WLC[237] WLC[238] WLC[239] WLC[240]
+ WLC[241] WLC[242] WLC[243] WLC[244] WLC[245] WLC[246] WLC[247] WLC[248]
+ WLC[249] WLC[250] WLC[251] WLC[252] WLC[253] WLC[254] WLC[255] PD[0] PD[1]
+ PD[2] PD[3] RWL RWL DBL CSH_ENB GRST BPUI SPUI ZRR VSB[0] VSB[1] VSB[2]
+ VSB[3] XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] DBL0 WMO[0] WMO[1]
+ WMO[2] XARMSBB[0] XARMSBB[1] XARMSBB[2] XARMSBB[3] LCLKB LXWB[0] LXWB[1]
+ LXWB[2] LXWB[3] ag_ctrl CSH_RR EN ENB RMO[0] RMO[1] RMO[2] T0EN QT[0] QT[1]
+ QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] CSH_LD
+ XARLSBA[0] XARLSBA[1] XARLSBA[2] XARLSBA[3] RWOUT CSH_YS[0] CSH_YS[1]
+ CSH_YS[2] CSH_YS[3] VSSX spram_4096x16m16b1pm2re1RE1M16_B1XD m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1SBNK_XDEC

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_EDG_R VDDA VSSX VSS VNW
+ PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10]
+ WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+ WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30]
+ WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40]
+ WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50]
+ WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+ WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70]
+ WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80]
+ WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90]
+ WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100]
+ WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109]
+ WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118]
+ WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127]
+ WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136]
+ WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145]
+ WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154]
+ WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163]
+ WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172]
+ WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181]
+ WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190]
+ WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199]
+ WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208]
+ WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217]
+ WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226]
+ WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235]
+ WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244]
+ WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253]
+ WL[254] WL[255] RWL
*.pininfo VDDA:B VSSX:B VSS:B VNW:B PWR:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.pininfo WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B
*.pininfo WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B
*.pininfo WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B
*.pininfo WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B
*.pininfo WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B
*.pininfo WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B
*.pininfo WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B
*.pininfo WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B
*.pininfo WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B
*.pininfo WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B
*.pininfo WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B
*.pininfo WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B
*.pininfo WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B
*.pininfo WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B
*.pininfo WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B
*.pininfo WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B
*.pininfo WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B
*.pininfo WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B
*.pininfo WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B
*.pininfo WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B
*.pininfo WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B
*.pininfo WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B
*.pininfo WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B
*.pininfo WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B
*.pininfo WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B
*.pininfo WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B
*.pininfo WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B
*.pininfo WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B
*.pininfo WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B
*.pininfo WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B
*.pininfo WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B
*.pininfo WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B
*.pininfo WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B
*.pininfo WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B
*.pininfo WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B
*.pininfo WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B
*.pininfo WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B
*.pininfo WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B
*.pininfo WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B
*.pininfo WL[253]:B WL[254]:B WL[255]:B RWL:B
XXc0r0 PWR VDDA VNW VSS VSSX bitcell_edge_cap m=1
XXc1r0 PWR VDDA VNW VSS VSSX WL[0] WL[1] WL[2] WL[3] bitcell_edge m=1
XXc2r0 PWR VDDA VNW VSS VSSX WL[4] WL[5] WL[6] WL[7] bitcell_edge m=1
XXc3r0 PWR VDDA VNW VSS VSSX WL[8] WL[9] WL[10] WL[11] bitcell_edge m=1
XXc4r0 PWR VDDA VNW VSS VSSX WL[12] WL[13] WL[14] WL[15] bitcell_edge m=1
XXc5r0 PWR VDDA VNW VSS VSSX WL[16] WL[17] WL[18] WL[19] bitcell_edge m=1
XXc6r0 PWR VDDA VNW VSS VSSX WL[20] WL[21] WL[22] WL[23] bitcell_edge m=1
XXc7r0 PWR VDDA VNW VSS VSSX WL[24] WL[25] WL[26] WL[27] bitcell_edge m=1
XXc8r0 PWR VDDA VNW VSS VSSX WL[28] WL[29] WL[30] WL[31] bitcell_edge m=1
XXc9r0 PWR VDDA VNW VSS VSSX WL[32] WL[33] WL[34] WL[35] bitcell_edge m=1
XXc10r0 PWR VDDA VNW VSS VSSX WL[36] WL[37] WL[38] WL[39] bitcell_edge m=1
XXc11r0 PWR VDDA VNW VSS VSSX WL[40] WL[41] WL[42] WL[43] bitcell_edge m=1
XXc12r0 PWR VDDA VNW VSS VSSX WL[44] WL[45] WL[46] WL[47] bitcell_edge m=1
XXc13r0 PWR VDDA VNW VSS VSSX WL[48] WL[49] WL[50] WL[51] bitcell_edge m=1
XXc14r0 PWR VDDA VNW VSS VSSX WL[52] WL[53] WL[54] WL[55] bitcell_edge m=1
XXc15r0 PWR VDDA VNW VSS VSSX WL[56] WL[57] WL[58] WL[59] bitcell_edge m=1
XXc16r0 PWR VDDA VNW VSS VSSX WL[60] WL[61] WL[62] WL[63] bitcell_edge m=1
XXc17r0 PWR VDDA VNW VSS VSSX WL[64] WL[65] WL[66] WL[67] bitcell_edge m=1
XXc18r0 PWR VDDA VNW VSS VSSX WL[68] WL[69] WL[70] WL[71] bitcell_edge m=1
XXc19r0 PWR VDDA VNW VSS VSSX WL[72] WL[73] WL[74] WL[75] bitcell_edge m=1
XXc20r0 PWR VDDA VNW VSS VSSX WL[76] WL[77] WL[78] WL[79] bitcell_edge m=1
XXc21r0 PWR VDDA VNW VSS VSSX WL[80] WL[81] WL[82] WL[83] bitcell_edge m=1
XXc22r0 PWR VDDA VNW VSS VSSX WL[84] WL[85] WL[86] WL[87] bitcell_edge m=1
XXc23r0 PWR VDDA VNW VSS VSSX WL[88] WL[89] WL[90] WL[91] bitcell_edge m=1
XXc24r0 PWR VDDA VNW VSS VSSX WL[92] WL[93] WL[94] WL[95] bitcell_edge m=1
XXc25r0 PWR VDDA VNW VSS VSSX WL[96] WL[97] WL[98] WL[99] bitcell_edge m=1
XXc26r0 PWR VDDA VNW VSS VSSX WL[100] WL[101] WL[102] WL[103] bitcell_edge m=1
XXc27r0 PWR VDDA VNW VSS VSSX WL[104] WL[105] WL[106] WL[107] bitcell_edge m=1
XXc28r0 PWR VDDA VNW VSS VSSX WL[108] WL[109] WL[110] WL[111] bitcell_edge m=1
XXc29r0 PWR VDDA VNW VSS VSSX WL[112] WL[113] WL[114] WL[115] bitcell_edge m=1
XXc30r0 PWR VDDA VNW VSS VSSX WL[116] WL[117] WL[118] WL[119] bitcell_edge m=1
XXc31r0 PWR VDDA VNW VSS VSSX WL[120] WL[121] WL[122] WL[123] bitcell_edge m=1
XXc32r0 PWR VDDA VNW VSS VSSX WL[124] WL[125] WL[126] WL[127] bitcell_edge m=1
XXc33r0 PWR VDDA VNW VSS VSSX WL[128] WL[129] WL[130] WL[131] bitcell_edge m=1
XXc34r0 PWR VDDA VNW VSS VSSX WL[132] WL[133] WL[134] WL[135] bitcell_edge m=1
XXc35r0 PWR VDDA VNW VSS VSSX WL[136] WL[137] WL[138] WL[139] bitcell_edge m=1
XXc36r0 PWR VDDA VNW VSS VSSX WL[140] WL[141] WL[142] WL[143] bitcell_edge m=1
XXc37r0 PWR VDDA VNW VSS VSSX WL[144] WL[145] WL[146] WL[147] bitcell_edge m=1
XXc38r0 PWR VDDA VNW VSS VSSX WL[148] WL[149] WL[150] WL[151] bitcell_edge m=1
XXc39r0 PWR VDDA VNW VSS VSSX WL[152] WL[153] WL[154] WL[155] bitcell_edge m=1
XXc40r0 PWR VDDA VNW VSS VSSX WL[156] WL[157] WL[158] WL[159] bitcell_edge m=1
XXc41r0 PWR VDDA VNW VSS VSSX WL[160] WL[161] WL[162] WL[163] bitcell_edge m=1
XXc42r0 PWR VDDA VNW VSS VSSX WL[164] WL[165] WL[166] WL[167] bitcell_edge m=1
XXc43r0 PWR VDDA VNW VSS VSSX WL[168] WL[169] WL[170] WL[171] bitcell_edge m=1
XXc44r0 PWR VDDA VNW VSS VSSX WL[172] WL[173] WL[174] WL[175] bitcell_edge m=1
XXc45r0 PWR VDDA VNW VSS VSSX WL[176] WL[177] WL[178] WL[179] bitcell_edge m=1
XXc46r0 PWR VDDA VNW VSS VSSX WL[180] WL[181] WL[182] WL[183] bitcell_edge m=1
XXc47r0 PWR VDDA VNW VSS VSSX WL[184] WL[185] WL[186] WL[187] bitcell_edge m=1
XXc48r0 PWR VDDA VNW VSS VSSX WL[188] WL[189] WL[190] WL[191] bitcell_edge m=1
XXc49r0 PWR VDDA VNW VSS VSSX WL[192] WL[193] WL[194] WL[195] bitcell_edge m=1
XXc50r0 PWR VDDA VNW VSS VSSX WL[196] WL[197] WL[198] WL[199] bitcell_edge m=1
XXc51r0 PWR VDDA VNW VSS VSSX WL[200] WL[201] WL[202] WL[203] bitcell_edge m=1
XXc52r0 PWR VDDA VNW VSS VSSX WL[204] WL[205] WL[206] WL[207] bitcell_edge m=1
XXc53r0 PWR VDDA VNW VSS VSSX WL[208] WL[209] WL[210] WL[211] bitcell_edge m=1
XXc54r0 PWR VDDA VNW VSS VSSX WL[212] WL[213] WL[214] WL[215] bitcell_edge m=1
XXc55r0 PWR VDDA VNW VSS VSSX WL[216] WL[217] WL[218] WL[219] bitcell_edge m=1
XXc56r0 PWR VDDA VNW VSS VSSX WL[220] WL[221] WL[222] WL[223] bitcell_edge m=1
XXc57r0 PWR VDDA VNW VSS VSSX WL[224] WL[225] WL[226] WL[227] bitcell_edge m=1
XXc58r0 PWR VDDA VNW VSS VSSX WL[228] WL[229] WL[230] WL[231] bitcell_edge m=1
XXc59r0 PWR VDDA VNW VSS VSSX WL[232] WL[233] WL[234] WL[235] bitcell_edge m=1
XXc60r0 PWR VDDA VNW VSS VSSX WL[236] WL[237] WL[238] WL[239] bitcell_edge m=1
XXc61r0 PWR VDDA VNW VSS VSSX WL[240] WL[241] WL[242] WL[243] bitcell_edge m=1
XXc62r0 PWR VDDA VNW VSS VSSX WL[244] WL[245] WL[246] WL[247] bitcell_edge m=1
XXc63r0 PWR VDDA VNW VSS VSSX WL[248] WL[249] WL[250] WL[251] bitcell_edge m=1
XXc64r0 PWR VDDA VNW VSS VSSX WL[252] WL[253] WL[254] WL[255] bitcell_edge m=1
XXc65r0 PWR RWL VDDA VNW VSS VSSX bitcell_edge_tmr_wl m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_EDG_R

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGER VDDA VSSX VSS RWL
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR
*.pininfo VDDA:B VSSX:B VSS:B RWL:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B
*.pininfo WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B
*.pininfo WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B
*.pininfo WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B
*.pininfo WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B
*.pininfo WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B
*.pininfo WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B
*.pininfo WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B
*.pininfo WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B
*.pininfo WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B
*.pininfo WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B
*.pininfo WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B
*.pininfo WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B
*.pininfo WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B
*.pininfo WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B
*.pininfo WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B
*.pininfo WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B
*.pininfo WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B
*.pininfo WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B
*.pininfo WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B
*.pininfo WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B
*.pininfo WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B
*.pininfo WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B
*.pininfo WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B
*.pininfo WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B
*.pininfo WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B
*.pininfo WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B
*.pininfo WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B
*.pininfo WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B
*.pininfo WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B
*.pininfo WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B
*.pininfo WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B
*.pininfo WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B
*.pininfo WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B
*.pininfo WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B
*.pininfo WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B
*.pininfo WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B
*.pininfo WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B
*.pininfo WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B
*.pininfo WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B
*.pininfo WL[254]:B WL[255]:B VNW:B PWR:B
XX00 VDDA VSSX VSS VNW PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7]
+ WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18]
+ WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28]
+ WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38]
+ WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48]
+ WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58]
+ WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68]
+ WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78]
+ WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88]
+ WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98]
+ WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107]
+ WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116]
+ WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125]
+ WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134]
+ WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143]
+ WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152]
+ WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161]
+ WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170]
+ WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179]
+ WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188]
+ WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197]
+ WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206]
+ WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215]
+ WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224]
+ WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233]
+ WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242]
+ WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251]
+ WL[252] WL[253] WL[254] WL[255] RWL
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_EDG_R m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGER

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE GD[0] GBW[0]
+ VSSX GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] BB[0] BB[1]
+ BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+ BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] VNW VSS VDDA PWR WL[0] WL[1]
+ WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL
+ BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6]
+ BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13]
+ BB_TOP[14] BB_TOP[15]
*.pininfo GD[0]:B GBW[0]:B VSSX:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B
*.pininfo BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.pininfo BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.pininfo BT[15]:B VNW:B VSS:B VDDA:B PWR:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.pininfo WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B
*.pininfo WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B
*.pininfo WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B
*.pininfo WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B
*.pininfo WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B
*.pininfo WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B
*.pininfo WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B
*.pininfo WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B
*.pininfo WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B
*.pininfo WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B
*.pininfo WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B
*.pininfo WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B
*.pininfo WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B
*.pininfo WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B
*.pininfo WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B
*.pininfo WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B
*.pininfo WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B
*.pininfo WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B
*.pininfo WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B
*.pininfo WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B
*.pininfo WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B
*.pininfo WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B
*.pininfo WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B
*.pininfo WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B
*.pininfo WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B
*.pininfo WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B
*.pininfo WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B
*.pininfo WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B
*.pininfo WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B
*.pininfo WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B
*.pininfo WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B
*.pininfo WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B
*.pininfo WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B
*.pininfo WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B
*.pininfo WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B
*.pininfo WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B
*.pininfo WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B
*.pininfo WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B
*.pininfo WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B
*.pininfo WL[253]:B WL[254]:B WL[255]:B RWL:B BB_TOP[0]:B BB_TOP[1]:B
*.pininfo BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B
*.pininfo BB_TOP[7]:B BB_TOP[8]:B BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B
*.pininfo BB_TOP[12]:B BB_TOP[13]:B BB_TOP[14]:B BB_TOP[15]:B
XXc0r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX bitcell_cap_cm16 m=1
XXc1r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[0] WL[1] WL[2] WL[3] bitcell_cm16 m=1
XXc2r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[4] WL[5] WL[6] WL[7] bitcell_cm16 m=1
XXc3r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[8] WL[9] WL[10] WL[11] bitcell_cm16 m=1
XXc4r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[12] WL[13] WL[14] WL[15] bitcell_cm16 m=1
XXc5r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[16] WL[17] WL[18] WL[19] bitcell_cm16 m=1
XXc6r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[20] WL[21] WL[22] WL[23] bitcell_cm16 m=1
XXc7r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[24] WL[25] WL[26] WL[27] bitcell_cm16 m=1
XXc8r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[28] WL[29] WL[30] WL[31] bitcell_cm16 m=1
XXc9r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[32] WL[33] WL[34] WL[35] bitcell_cm16 m=1
XXc10r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[36] WL[37] WL[38] WL[39] bitcell_cm16 m=1
XXc11r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[40] WL[41] WL[42] WL[43] bitcell_cm16 m=1
XXc12r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[44] WL[45] WL[46] WL[47] bitcell_cm16 m=1
XXc13r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[48] WL[49] WL[50] WL[51] bitcell_cm16 m=1
XXc14r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[52] WL[53] WL[54] WL[55] bitcell_cm16 m=1
XXc15r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[56] WL[57] WL[58] WL[59] bitcell_cm16 m=1
XXc16r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[60] WL[61] WL[62] WL[63] bitcell_cm16 m=1
XXc17r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[64] WL[65] WL[66] WL[67] bitcell_cm16 m=1
XXc18r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[68] WL[69] WL[70] WL[71] bitcell_cm16 m=1
XXc19r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[72] WL[73] WL[74] WL[75] bitcell_cm16 m=1
XXc20r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[76] WL[77] WL[78] WL[79] bitcell_cm16 m=1
XXc21r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[80] WL[81] WL[82] WL[83] bitcell_cm16 m=1
XXc22r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[84] WL[85] WL[86] WL[87] bitcell_cm16 m=1
XXc23r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[88] WL[89] WL[90] WL[91] bitcell_cm16 m=1
XXc24r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[92] WL[93] WL[94] WL[95] bitcell_cm16 m=1
XXc25r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[96] WL[97] WL[98] WL[99] bitcell_cm16 m=1
XXc26r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[100] WL[101] WL[102] WL[103] bitcell_cm16 m=1
XXc27r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[104] WL[105] WL[106] WL[107] bitcell_cm16 m=1
XXc28r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[108] WL[109] WL[110] WL[111] bitcell_cm16 m=1
XXc29r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[112] WL[113] WL[114] WL[115] bitcell_cm16 m=1
XXc30r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[116] WL[117] WL[118] WL[119] bitcell_cm16 m=1
XXc31r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[120] WL[121] WL[122] WL[123] bitcell_cm16 m=1
XXc32r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[124] WL[125] WL[126] WL[127] bitcell_cm16 m=1
XXc33r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[128] WL[129] WL[130] WL[131] bitcell_cm16 m=1
XXc34r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[132] WL[133] WL[134] WL[135] bitcell_cm16 m=1
XXc35r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[136] WL[137] WL[138] WL[139] bitcell_cm16 m=1
XXc36r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[140] WL[141] WL[142] WL[143] bitcell_cm16 m=1
XXc37r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[144] WL[145] WL[146] WL[147] bitcell_cm16 m=1
XXc38r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[148] WL[149] WL[150] WL[151] bitcell_cm16 m=1
XXc39r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[152] WL[153] WL[154] WL[155] bitcell_cm16 m=1
XXc40r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[156] WL[157] WL[158] WL[159] bitcell_cm16 m=1
XXc41r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[160] WL[161] WL[162] WL[163] bitcell_cm16 m=1
XXc42r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[164] WL[165] WL[166] WL[167] bitcell_cm16 m=1
XXc43r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[168] WL[169] WL[170] WL[171] bitcell_cm16 m=1
XXc44r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[172] WL[173] WL[174] WL[175] bitcell_cm16 m=1
XXc45r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[176] WL[177] WL[178] WL[179] bitcell_cm16 m=1
XXc46r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[180] WL[181] WL[182] WL[183] bitcell_cm16 m=1
XXc47r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[184] WL[185] WL[186] WL[187] bitcell_cm16 m=1
XXc48r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[188] WL[189] WL[190] WL[191] bitcell_cm16 m=1
XXc49r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[192] WL[193] WL[194] WL[195] bitcell_cm16 m=1
XXc50r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[196] WL[197] WL[198] WL[199] bitcell_cm16 m=1
XXc51r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[200] WL[201] WL[202] WL[203] bitcell_cm16 m=1
XXc52r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[204] WL[205] WL[206] WL[207] bitcell_cm16 m=1
XXc53r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[208] WL[209] WL[210] WL[211] bitcell_cm16 m=1
XXc54r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[212] WL[213] WL[214] WL[215] bitcell_cm16 m=1
XXc55r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[216] WL[217] WL[218] WL[219] bitcell_cm16 m=1
XXc56r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[220] WL[221] WL[222] WL[223] bitcell_cm16 m=1
XXc57r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[224] WL[225] WL[226] WL[227] bitcell_cm16 m=1
XXc58r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[228] WL[229] WL[230] WL[231] bitcell_cm16 m=1
XXc59r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[232] WL[233] WL[234] WL[235] bitcell_cm16 m=1
XXc60r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[236] WL[237] WL[238] WL[239] bitcell_cm16 m=1
XXc61r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[240] WL[241] WL[242] WL[243] bitcell_cm16 m=1
XXc62r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[244] WL[245] WL[246] WL[247] bitcell_cm16 m=1
XXc63r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[248] WL[249] WL[250] WL[251] bitcell_cm16 m=1
XXc64r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW[0]
+ GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA
+ VNW VSS VSSX WL[252] WL[253] WL[254] WL[255] bitcell_cm16 m=1
XXc65r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3]
+ BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10]
+ BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] BT[0] BT[1] BT[2]
+ BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] GBW[0] GD[0] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] PWR RWL VDDA VNW VSS VSSX local_tmr_wl_cm16 m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY GD[0] GBW[0] VSSX
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] BB[0] BB[1] BB[2]
+ BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+ BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] RWL BB_TOP[0] BB_TOP[1] BB_TOP[2]
+ BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9]
+ BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] WL[0]
+ WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+ WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+ WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+ WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+ WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+ WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+ WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72]
+ WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82]
+ WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92]
+ WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102]
+ WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111]
+ WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120]
+ WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129]
+ WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138]
+ WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147]
+ WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156]
+ WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165]
+ WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174]
+ WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183]
+ WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192]
+ WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201]
+ WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210]
+ WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219]
+ WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228]
+ WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237]
+ WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246]
+ WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW
+ VSS VDDA PWR GD[1] GBW[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+ BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18]
+ BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+ BT[29] BT[30] BT[31] BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20]
+ BB_TOP[21] BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26]
+ BB_TOP[27] BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] GD[2] GBW[2] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] BB[32] BB[33] BB[34]
+ BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44]
+ BB[45] BB[46] BB[47] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38]
+ BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BB_TOP[32]
+ BB_TOP[33] BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38]
+ BB_TOP[39] BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44]
+ BB_TOP[45] BB_TOP[46] BB_TOP[47] GD[3] GBW[3] GRD0[12] GRD0[13] GRD0[14]
+ GRD0[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD3[12] GRD3[13] GRD3[14] GRD3[15] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+ BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BB_TOP[48]
+ BB_TOP[49] BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54]
+ BB_TOP[55] BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60]
+ BB_TOP[61] BB_TOP[62] BB_TOP[63] GD[4] GBW[4] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19] BB[64] BB[65] BB[66] BB[67]
+ BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77]
+ BB[78] BB[79] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71]
+ BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BB_TOP[64]
+ BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69] BB_TOP[70]
+ BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75] BB_TOP[76]
+ BB_TOP[77] BB_TOP[78] BB_TOP[79] GD[5] GBW[5] GRD0[20] GRD0[21] GRD0[22]
+ GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] BB[80] BB[81] BB[82] BB[83]
+ BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+ BB[94] BB[95] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87]
+ BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BB_TOP[80]
+ BB_TOP[81] BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86]
+ BB_TOP[87] BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92]
+ BB_TOP[93] BB_TOP[94] BB_TOP[95] GD[6] GBW[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] BB[96] BB[97] BB[98] BB[99]
+ BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+ BB[109] BB[110] BB[111] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102]
+ BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111]
+ BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101]
+ BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107]
+ BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111] GD[7] GBW[7] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29] GRD3[30] GRD3[31] BB[112]
+ BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+ BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[112] BT[113] BT[114]
+ BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+ BT[124] BT[125] BT[126] BT[127] BB_TOP[112] BB_TOP[113] BB_TOP[114]
+ BB_TOP[115] BB_TOP[116] BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120]
+ BB_TOP[121] BB_TOP[122] BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126]
+ BB_TOP[127]
*.pininfo GD[0]:B GBW[0]:B VSSX:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD2[0]:B GRD2[1]:B
*.pininfo GRD2[2]:B GRD2[3]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B
*.pininfo BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B
*.pininfo BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B
*.pininfo BT[15]:B RWL:B BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B
*.pininfo BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BB_TOP[8]:B
*.pininfo BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B BB_TOP[12]:B BB_TOP[13]:B
*.pininfo BB_TOP[14]:B BB_TOP[15]:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B
*.pininfo WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B
*.pininfo WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B
*.pininfo WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B
*.pininfo WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B
*.pininfo WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B
*.pininfo WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B
*.pininfo WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B
*.pininfo WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B
*.pininfo WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B
*.pininfo WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B
*.pininfo WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B
*.pininfo WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B
*.pininfo WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B
*.pininfo WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B
*.pininfo WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B
*.pininfo WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B
*.pininfo WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B
*.pininfo WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B
*.pininfo WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B
*.pininfo WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B
*.pininfo WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B
*.pininfo WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B
*.pininfo WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B
*.pininfo WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B
*.pininfo WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B
*.pininfo WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B
*.pininfo WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B
*.pininfo WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B
*.pininfo WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B
*.pininfo WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B
*.pininfo WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B
*.pininfo WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B
*.pininfo WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B
*.pininfo WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B
*.pininfo WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B
*.pininfo WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B
*.pininfo WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B
*.pininfo WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B
*.pininfo WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B
*.pininfo WL[254]:B WL[255]:B VNW:B VSS:B VDDA:B PWR:B GD[1]:B GBW[1]:B
*.pininfo GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD1[4]:B GRD1[5]:B
*.pininfo GRD1[6]:B GRD1[7]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B
*.pininfo GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B BB[16]:B BB[17]:B BB[18]:B
*.pininfo BB[19]:B BB[20]:B BB[21]:B BB[22]:B BB[23]:B BB[24]:B BB[25]:B
*.pininfo BB[26]:B BB[27]:B BB[28]:B BB[29]:B BB[30]:B BB[31]:B BT[16]:B
*.pininfo BT[17]:B BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B BT[23]:B
*.pininfo BT[24]:B BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B BT[30]:B
*.pininfo BT[31]:B BB_TOP[16]:B BB_TOP[17]:B BB_TOP[18]:B BB_TOP[19]:B
*.pininfo BB_TOP[20]:B BB_TOP[21]:B BB_TOP[22]:B BB_TOP[23]:B BB_TOP[24]:B
*.pininfo BB_TOP[25]:B BB_TOP[26]:B BB_TOP[27]:B BB_TOP[28]:B BB_TOP[29]:B
*.pininfo BB_TOP[30]:B BB_TOP[31]:B GD[2]:B GBW[2]:B GRD0[8]:B GRD0[9]:B
*.pininfo GRD0[10]:B GRD0[11]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B
*.pininfo GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD3[8]:B GRD3[9]:B
*.pininfo GRD3[10]:B GRD3[11]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B BB[36]:B
*.pininfo BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B BB[43]:B
*.pininfo BB[44]:B BB[45]:B BB[46]:B BB[47]:B BT[32]:B BT[33]:B BT[34]:B
*.pininfo BT[35]:B BT[36]:B BT[37]:B BT[38]:B BT[39]:B BT[40]:B BT[41]:B
*.pininfo BT[42]:B BT[43]:B BT[44]:B BT[45]:B BT[46]:B BT[47]:B BB_TOP[32]:B
*.pininfo BB_TOP[33]:B BB_TOP[34]:B BB_TOP[35]:B BB_TOP[36]:B BB_TOP[37]:B
*.pininfo BB_TOP[38]:B BB_TOP[39]:B BB_TOP[40]:B BB_TOP[41]:B BB_TOP[42]:B
*.pininfo BB_TOP[43]:B BB_TOP[44]:B BB_TOP[45]:B BB_TOP[46]:B BB_TOP[47]:B
*.pininfo GD[3]:B GBW[3]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B
*.pininfo GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD2[12]:B GRD2[13]:B
*.pininfo GRD2[14]:B GRD2[15]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B
*.pininfo BB[48]:B BB[49]:B BB[50]:B BB[51]:B BB[52]:B BB[53]:B BB[54]:B
*.pininfo BB[55]:B BB[56]:B BB[57]:B BB[58]:B BB[59]:B BB[60]:B BB[61]:B
*.pininfo BB[62]:B BB[63]:B BT[48]:B BT[49]:B BT[50]:B BT[51]:B BT[52]:B
*.pininfo BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B BT[58]:B BT[59]:B
*.pininfo BT[60]:B BT[61]:B BT[62]:B BT[63]:B BB_TOP[48]:B BB_TOP[49]:B
*.pininfo BB_TOP[50]:B BB_TOP[51]:B BB_TOP[52]:B BB_TOP[53]:B BB_TOP[54]:B
*.pininfo BB_TOP[55]:B BB_TOP[56]:B BB_TOP[57]:B BB_TOP[58]:B BB_TOP[59]:B
*.pininfo BB_TOP[60]:B BB_TOP[61]:B BB_TOP[62]:B BB_TOP[63]:B GD[4]:B
*.pininfo GBW[4]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B BB[64]:B
*.pininfo BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B BB[71]:B
*.pininfo BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B BB[78]:B
*.pininfo BB[79]:B BT[64]:B BT[65]:B BT[66]:B BT[67]:B BT[68]:B BT[69]:B
*.pininfo BT[70]:B BT[71]:B BT[72]:B BT[73]:B BT[74]:B BT[75]:B BT[76]:B
*.pininfo BT[77]:B BT[78]:B BT[79]:B BB_TOP[64]:B BB_TOP[65]:B BB_TOP[66]:B
*.pininfo BB_TOP[67]:B BB_TOP[68]:B BB_TOP[69]:B BB_TOP[70]:B BB_TOP[71]:B
*.pininfo BB_TOP[72]:B BB_TOP[73]:B BB_TOP[74]:B BB_TOP[75]:B BB_TOP[76]:B
*.pininfo BB_TOP[77]:B BB_TOP[78]:B BB_TOP[79]:B GD[5]:B GBW[5]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B BB[80]:B BB[81]:B BB[82]:B
*.pininfo BB[83]:B BB[84]:B BB[85]:B BB[86]:B BB[87]:B BB[88]:B BB[89]:B
*.pininfo BB[90]:B BB[91]:B BB[92]:B BB[93]:B BB[94]:B BB[95]:B BT[80]:B
*.pininfo BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B BT[86]:B BT[87]:B
*.pininfo BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B BT[93]:B BT[94]:B
*.pininfo BT[95]:B BB_TOP[80]:B BB_TOP[81]:B BB_TOP[82]:B BB_TOP[83]:B
*.pininfo BB_TOP[84]:B BB_TOP[85]:B BB_TOP[86]:B BB_TOP[87]:B BB_TOP[88]:B
*.pininfo BB_TOP[89]:B BB_TOP[90]:B BB_TOP[91]:B BB_TOP[92]:B BB_TOP[93]:B
*.pininfo BB_TOP[94]:B BB_TOP[95]:B GD[6]:B GBW[6]:B GRD0[24]:B GRD0[25]:B
*.pininfo GRD0[26]:B GRD0[27]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B
*.pininfo GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD3[24]:B GRD3[25]:B
*.pininfo GRD3[26]:B GRD3[27]:B BB[96]:B BB[97]:B BB[98]:B BB[99]:B BB[100]:B
*.pininfo BB[101]:B BB[102]:B BB[103]:B BB[104]:B BB[105]:B BB[106]:B
*.pininfo BB[107]:B BB[108]:B BB[109]:B BB[110]:B BB[111]:B BT[96]:B BT[97]:B
*.pininfo BT[98]:B BT[99]:B BT[100]:B BT[101]:B BT[102]:B BT[103]:B BT[104]:B
*.pininfo BT[105]:B BT[106]:B BT[107]:B BT[108]:B BT[109]:B BT[110]:B
*.pininfo BT[111]:B BB_TOP[96]:B BB_TOP[97]:B BB_TOP[98]:B BB_TOP[99]:B
*.pininfo BB_TOP[100]:B BB_TOP[101]:B BB_TOP[102]:B BB_TOP[103]:B
*.pininfo BB_TOP[104]:B BB_TOP[105]:B BB_TOP[106]:B BB_TOP[107]:B
*.pininfo BB_TOP[108]:B BB_TOP[109]:B BB_TOP[110]:B BB_TOP[111]:B GD[7]:B
*.pininfo GBW[7]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B
*.pininfo GRD2[31]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B BB[112]:B
*.pininfo BB[113]:B BB[114]:B BB[115]:B BB[116]:B BB[117]:B BB[118]:B
*.pininfo BB[119]:B BB[120]:B BB[121]:B BB[122]:B BB[123]:B BB[124]:B
*.pininfo BB[125]:B BB[126]:B BB[127]:B BT[112]:B BT[113]:B BT[114]:B
*.pininfo BT[115]:B BT[116]:B BT[117]:B BT[118]:B BT[119]:B BT[120]:B
*.pininfo BT[121]:B BT[122]:B BT[123]:B BT[124]:B BT[125]:B BT[126]:B
*.pininfo BT[127]:B BB_TOP[112]:B BB_TOP[113]:B BB_TOP[114]:B BB_TOP[115]:B
*.pininfo BB_TOP[116]:B BB_TOP[117]:B BB_TOP[118]:B BB_TOP[119]:B
*.pininfo BB_TOP[120]:B BB_TOP[121]:B BB_TOP[122]:B BB_TOP[123]:B
*.pininfo BB_TOP[124]:B BB_TOP[125]:B BB_TOP[126]:B BB_TOP[127]:B
XX00 GD[0] GBW[0] VSSX GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] VNW VSS
+ VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10]
+ WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+ WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30]
+ WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40]
+ WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50]
+ WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+ WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70]
+ WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80]
+ WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90]
+ WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100]
+ WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109]
+ WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118]
+ WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127]
+ WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136]
+ WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145]
+ WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154]
+ WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163]
+ WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172]
+ WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181]
+ WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190]
+ WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199]
+ WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208]
+ WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217]
+ WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226]
+ WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235]
+ WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244]
+ WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253]
+ WL[254] WL[255] RWL BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4]
+ BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11]
+ BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
XX01 GD[1] GBW[1] VSSX GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+ BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18]
+ BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+ BT[29] BT[30] BT[31] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5]
+ WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16]
+ WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26]
+ WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36]
+ WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46]
+ WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56]
+ WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66]
+ WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76]
+ WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86]
+ WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96]
+ WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[16] BB_TOP[17]
+ BB_TOP[18] BB_TOP[19] BB_TOP[20] BB_TOP[21] BB_TOP[22] BB_TOP[23]
+ BB_TOP[24] BB_TOP[25] BB_TOP[26] BB_TOP[27] BB_TOP[28] BB_TOP[29]
+ BB_TOP[30] BB_TOP[31]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
XX02 GD[2] GBW[2] VSSX GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9]
+ GRD1[10] GRD1[11] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD3[8] GRD3[9]
+ GRD3[10] GRD3[11] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39]
+ BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BT[32] BT[33]
+ BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+ BT[44] BT[45] BT[46] BT[47] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[32] BB_TOP[33]
+ BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38] BB_TOP[39]
+ BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44] BB_TOP[45]
+ BB_TOP[46] BB_TOP[47]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
XX03 GD[3] GBW[3] VSSX GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD3[12] GRD3[13]
+ GRD3[14] GRD3[15] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55]
+ BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[48] BT[49]
+ BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+ BT[60] BT[61] BT[62] BT[63] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[48] BB_TOP[49]
+ BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55]
+ BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61]
+ BB_TOP[62] BB_TOP[63]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
XX04 GD[4] GBW[4] VSSX GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD1[16] GRD1[17]
+ GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD3[16] GRD3[17]
+ GRD3[18] GRD3[19] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+ BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BT[64] BT[65]
+ BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75]
+ BT[76] BT[77] BT[78] BT[79] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[64] BB_TOP[65]
+ BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69] BB_TOP[70] BB_TOP[71]
+ BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75] BB_TOP[76] BB_TOP[77]
+ BB_TOP[78] BB_TOP[79]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
XX05 GD[5] GBW[5] VSSX GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD3[20] GRD3[21]
+ GRD3[22] GRD3[23] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87]
+ BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BT[80] BT[81]
+ BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91]
+ BT[92] BT[93] BT[94] BT[95] VNW VSS VDDA PWR WL[0] WL[1] WL[2] WL[3] WL[4]
+ WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+ WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+ WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+ WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+ WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+ WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+ WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+ WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+ WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+ WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL BB_TOP[80] BB_TOP[81]
+ BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86] BB_TOP[87]
+ BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92] BB_TOP[93]
+ BB_TOP[94] BB_TOP[95]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
XX06 GD[6] GBW[6] VSSX GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD1[24] GRD1[25]
+ GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD3[24] GRD3[25]
+ GRD3[26] GRD3[27] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102]
+ BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111]
+ BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+ BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] VNW VSS VDDA PWR WL[0]
+ WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+ WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+ WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+ WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+ WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+ WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+ WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72]
+ WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82]
+ WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92]
+ WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102]
+ WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111]
+ WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120]
+ WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129]
+ WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138]
+ WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147]
+ WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156]
+ WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165]
+ WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174]
+ WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183]
+ WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192]
+ WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201]
+ WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210]
+ WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219]
+ WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228]
+ WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237]
+ WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246]
+ WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] RWL
+ BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101]
+ BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107]
+ BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
XX07 GD[7] GBW[7] VSSX GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118]
+ BB[119] BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127]
+ BT[112] BT[113] BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120]
+ BT[121] BT[122] BT[123] BT[124] BT[125] BT[126] BT[127] VNW VSS VDDA PWR
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] RWL BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115] BB_TOP[116]
+ BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121] BB_TOP[122]
+ BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_SLICE m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARE VSSX GD GBW GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7]
+ BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD0[0] GRD0[1] GRD0[2]
+ GRD0[3] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] VSS VDDA PWR VNW WL[0] WL[1] WL[2] WL[3]
+ WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14]
+ WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24]
+ WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34]
+ WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44]
+ WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54]
+ WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64]
+ WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74]
+ WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84]
+ WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94]
+ WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104]
+ WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113]
+ WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122]
+ WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131]
+ WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140]
+ WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149]
+ WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158]
+ WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167]
+ WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176]
+ WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185]
+ WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194]
+ WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203]
+ WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212]
+ WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221]
+ WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230]
+ WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239]
+ WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248]
+ WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] BB_TOP[0] BB_TOP[1]
+ BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8]
+ BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ RWL
*.pininfo VSSX:B GD:B GBW:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B BT[0]:B
*.pininfo BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B
*.pininfo BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B
*.pininfo GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD1[0]:B GRD1[1]:B
*.pininfo GRD1[2]:B GRD1[3]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B VSS:B
*.pininfo VDDA:B PWR:B VNW:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B WL[5]:B
*.pininfo WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B WL[13]:B
*.pininfo WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B WL[20]:B
*.pininfo WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B WL[27]:B
*.pininfo WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B WL[34]:B
*.pininfo WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B WL[41]:B
*.pininfo WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B WL[48]:B
*.pininfo WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B WL[55]:B
*.pininfo WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B WL[62]:B
*.pininfo WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B WL[69]:B
*.pininfo WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B WL[76]:B
*.pininfo WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B WL[83]:B
*.pininfo WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B WL[90]:B
*.pininfo WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B WL[97]:B
*.pininfo WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B WL[104]:B
*.pininfo WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B WL[110]:B
*.pininfo WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B WL[116]:B
*.pininfo WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B WL[122]:B
*.pininfo WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B WL[128]:B
*.pininfo WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B WL[134]:B
*.pininfo WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B WL[140]:B
*.pininfo WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B WL[146]:B
*.pininfo WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B WL[152]:B
*.pininfo WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B WL[158]:B
*.pininfo WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B WL[164]:B
*.pininfo WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B WL[170]:B
*.pininfo WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B WL[176]:B
*.pininfo WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B WL[182]:B
*.pininfo WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B WL[188]:B
*.pininfo WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B WL[194]:B
*.pininfo WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B WL[200]:B
*.pininfo WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B WL[206]:B
*.pininfo WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B WL[212]:B
*.pininfo WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B WL[218]:B
*.pininfo WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B WL[224]:B
*.pininfo WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B WL[230]:B
*.pininfo WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B WL[236]:B
*.pininfo WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B WL[242]:B
*.pininfo WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B WL[248]:B
*.pininfo WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B WL[254]:B
*.pininfo WL[255]:B BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B
*.pininfo BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BB_TOP[8]:B
*.pininfo BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B BB_TOP[12]:B BB_TOP[13]:B
*.pininfo BB_TOP[14]:B BB_TOP[15]:B RWL:B
XXc0r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX bitcell_cap_cm16 m=1
XXc1r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[0] WL[1] WL[2] WL[3] bitcell_cm16 m=1
XXc2r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[4] WL[5] WL[6] WL[7] bitcell_cm16 m=1
XXc3r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[8] WL[9] WL[10] WL[11] bitcell_cm16 m=1
XXc4r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[12] WL[13] WL[14] WL[15] bitcell_cm16 m=1
XXc5r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[16] WL[17] WL[18] WL[19] bitcell_cm16 m=1
XXc6r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[20] WL[21] WL[22] WL[23] bitcell_cm16 m=1
XXc7r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[24] WL[25] WL[26] WL[27] bitcell_cm16 m=1
XXc8r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[28] WL[29] WL[30] WL[31] bitcell_cm16 m=1
XXc9r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[32] WL[33] WL[34] WL[35] bitcell_cm16 m=1
XXc10r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[36] WL[37] WL[38] WL[39] bitcell_cm16 m=1
XXc11r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[40] WL[41] WL[42] WL[43] bitcell_cm16 m=1
XXc12r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[44] WL[45] WL[46] WL[47] bitcell_cm16 m=1
XXc13r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[48] WL[49] WL[50] WL[51] bitcell_cm16 m=1
XXc14r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[52] WL[53] WL[54] WL[55] bitcell_cm16 m=1
XXc15r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[56] WL[57] WL[58] WL[59] bitcell_cm16 m=1
XXc16r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[60] WL[61] WL[62] WL[63] bitcell_cm16 m=1
XXc17r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[64] WL[65] WL[66] WL[67] bitcell_cm16 m=1
XXc18r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[68] WL[69] WL[70] WL[71] bitcell_cm16 m=1
XXc19r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[72] WL[73] WL[74] WL[75] bitcell_cm16 m=1
XXc20r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[76] WL[77] WL[78] WL[79] bitcell_cm16 m=1
XXc21r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[80] WL[81] WL[82] WL[83] bitcell_cm16 m=1
XXc22r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[84] WL[85] WL[86] WL[87] bitcell_cm16 m=1
XXc23r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[88] WL[89] WL[90] WL[91] bitcell_cm16 m=1
XXc24r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[92] WL[93] WL[94] WL[95] bitcell_cm16 m=1
XXc25r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[96] WL[97] WL[98] WL[99] bitcell_cm16 m=1
XXc26r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[100] WL[101] WL[102] WL[103] bitcell_cm16 m=1
XXc27r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[104] WL[105] WL[106] WL[107] bitcell_cm16 m=1
XXc28r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[108] WL[109] WL[110] WL[111] bitcell_cm16 m=1
XXc29r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[112] WL[113] WL[114] WL[115] bitcell_cm16 m=1
XXc30r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[116] WL[117] WL[118] WL[119] bitcell_cm16 m=1
XXc31r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[120] WL[121] WL[122] WL[123] bitcell_cm16 m=1
XXc32r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[124] WL[125] WL[126] WL[127] bitcell_cm16 m=1
XXc33r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[128] WL[129] WL[130] WL[131] bitcell_cm16 m=1
XXc34r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[132] WL[133] WL[134] WL[135] bitcell_cm16 m=1
XXc35r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[136] WL[137] WL[138] WL[139] bitcell_cm16 m=1
XXc36r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[140] WL[141] WL[142] WL[143] bitcell_cm16 m=1
XXc37r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[144] WL[145] WL[146] WL[147] bitcell_cm16 m=1
XXc38r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[148] WL[149] WL[150] WL[151] bitcell_cm16 m=1
XXc39r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[152] WL[153] WL[154] WL[155] bitcell_cm16 m=1
XXc40r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[156] WL[157] WL[158] WL[159] bitcell_cm16 m=1
XXc41r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[160] WL[161] WL[162] WL[163] bitcell_cm16 m=1
XXc42r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[164] WL[165] WL[166] WL[167] bitcell_cm16 m=1
XXc43r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[168] WL[169] WL[170] WL[171] bitcell_cm16 m=1
XXc44r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[172] WL[173] WL[174] WL[175] bitcell_cm16 m=1
XXc45r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[176] WL[177] WL[178] WL[179] bitcell_cm16 m=1
XXc46r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[180] WL[181] WL[182] WL[183] bitcell_cm16 m=1
XXc47r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[184] WL[185] WL[186] WL[187] bitcell_cm16 m=1
XXc48r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[188] WL[189] WL[190] WL[191] bitcell_cm16 m=1
XXc49r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[192] WL[193] WL[194] WL[195] bitcell_cm16 m=1
XXc50r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[196] WL[197] WL[198] WL[199] bitcell_cm16 m=1
XXc51r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[200] WL[201] WL[202] WL[203] bitcell_cm16 m=1
XXc52r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[204] WL[205] WL[206] WL[207] bitcell_cm16 m=1
XXc53r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[208] WL[209] WL[210] WL[211] bitcell_cm16 m=1
XXc54r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[212] WL[213] WL[214] WL[215] bitcell_cm16 m=1
XXc55r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[216] WL[217] WL[218] WL[219] bitcell_cm16 m=1
XXc56r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[220] WL[221] WL[222] WL[223] bitcell_cm16 m=1
XXc57r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[224] WL[225] WL[226] WL[227] bitcell_cm16 m=1
XXc58r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[228] WL[229] WL[230] WL[231] bitcell_cm16 m=1
XXc59r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[232] WL[233] WL[234] WL[235] bitcell_cm16 m=1
XXc60r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[236] WL[237] WL[238] WL[239] bitcell_cm16 m=1
XXc61r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[240] WL[241] WL[242] WL[243] bitcell_cm16 m=1
XXc62r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[244] WL[245] WL[246] WL[247] bitcell_cm16 m=1
XXc63r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[248] WL[249] WL[250] WL[251] bitcell_cm16 m=1
XXc64r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] GBW GD
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] PWR VDDA VNW VSS
+ VSSX WL[252] WL[253] WL[254] WL[255] bitcell_cm16 m=1
XXc65r0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+ BB[11] BB[12] BB[13] BB[14] BB[15] BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3]
+ BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10]
+ BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] BT[0] BT[1] BT[2]
+ BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] GBW GD GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] PWR RWL VDDA VNW VSS VSSX local_tmr_wl_cm16 m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARE

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BA_RED VSSX RGD RGBW
+ RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4]
+ RBT[5] RBT[6] RBT[7] RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14]
+ RBT[15] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGRD1[0] RGRD1[1] RGRD1[2]
+ RGRD1[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RBB[0] RBB[1] RBB[2] RBB[3]
+ RBB[4] RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13]
+ RBB[14] RBB[15] BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5]
+ BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12]
+ BB_TOP[13] BB_TOP[14] BB_TOP[15] VSS WL[0] WL[1] WL[2] WL[3] WL[4] WL[5]
+ WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16]
+ WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26]
+ WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36]
+ WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46]
+ WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56]
+ WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66]
+ WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76]
+ WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86]
+ WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96]
+ WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105]
+ WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114]
+ WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123]
+ WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132]
+ WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141]
+ WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150]
+ WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159]
+ WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168]
+ WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177]
+ WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186]
+ WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195]
+ WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204]
+ WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213]
+ WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222]
+ WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231]
+ WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240]
+ WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249]
+ WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW VDDA PWR
*.pininfo VSSX:B RGD:B RGBW:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B
*.pininfo RBT[0]:B RBT[1]:B RBT[2]:B RBT[3]:B RBT[4]:B RBT[5]:B RBT[6]:B
*.pininfo RBT[7]:B RBT[8]:B RBT[9]:B RBT[10]:B RBT[11]:B RBT[12]:B RBT[13]:B
*.pininfo RBT[14]:B RBT[15]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B
*.pininfo RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RBB[0]:B RBB[1]:B RBB[2]:B RBB[3]:B RBB[4]:B
*.pininfo RBB[5]:B RBB[6]:B RBB[7]:B RBB[8]:B RBB[9]:B RBB[10]:B RBB[11]:B
*.pininfo RBB[12]:B RBB[13]:B RBB[14]:B RBB[15]:B BB_TOP[0]:B BB_TOP[1]:B
*.pininfo BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B
*.pininfo BB_TOP[7]:B BB_TOP[8]:B BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B
*.pininfo BB_TOP[12]:B BB_TOP[13]:B BB_TOP[14]:B BB_TOP[15]:B VSS:B WL[0]:B
*.pininfo WL[1]:B WL[2]:B WL[3]:B WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B
*.pininfo WL[9]:B WL[10]:B WL[11]:B WL[12]:B WL[13]:B WL[14]:B WL[15]:B
*.pininfo WL[16]:B WL[17]:B WL[18]:B WL[19]:B WL[20]:B WL[21]:B WL[22]:B
*.pininfo WL[23]:B WL[24]:B WL[25]:B WL[26]:B WL[27]:B WL[28]:B WL[29]:B
*.pininfo WL[30]:B WL[31]:B WL[32]:B WL[33]:B WL[34]:B WL[35]:B WL[36]:B
*.pininfo WL[37]:B WL[38]:B WL[39]:B WL[40]:B WL[41]:B WL[42]:B WL[43]:B
*.pininfo WL[44]:B WL[45]:B WL[46]:B WL[47]:B WL[48]:B WL[49]:B WL[50]:B
*.pininfo WL[51]:B WL[52]:B WL[53]:B WL[54]:B WL[55]:B WL[56]:B WL[57]:B
*.pininfo WL[58]:B WL[59]:B WL[60]:B WL[61]:B WL[62]:B WL[63]:B WL[64]:B
*.pininfo WL[65]:B WL[66]:B WL[67]:B WL[68]:B WL[69]:B WL[70]:B WL[71]:B
*.pininfo WL[72]:B WL[73]:B WL[74]:B WL[75]:B WL[76]:B WL[77]:B WL[78]:B
*.pininfo WL[79]:B WL[80]:B WL[81]:B WL[82]:B WL[83]:B WL[84]:B WL[85]:B
*.pininfo WL[86]:B WL[87]:B WL[88]:B WL[89]:B WL[90]:B WL[91]:B WL[92]:B
*.pininfo WL[93]:B WL[94]:B WL[95]:B WL[96]:B WL[97]:B WL[98]:B WL[99]:B
*.pininfo WL[100]:B WL[101]:B WL[102]:B WL[103]:B WL[104]:B WL[105]:B
*.pininfo WL[106]:B WL[107]:B WL[108]:B WL[109]:B WL[110]:B WL[111]:B
*.pininfo WL[112]:B WL[113]:B WL[114]:B WL[115]:B WL[116]:B WL[117]:B
*.pininfo WL[118]:B WL[119]:B WL[120]:B WL[121]:B WL[122]:B WL[123]:B
*.pininfo WL[124]:B WL[125]:B WL[126]:B WL[127]:B WL[128]:B WL[129]:B
*.pininfo WL[130]:B WL[131]:B WL[132]:B WL[133]:B WL[134]:B WL[135]:B
*.pininfo WL[136]:B WL[137]:B WL[138]:B WL[139]:B WL[140]:B WL[141]:B
*.pininfo WL[142]:B WL[143]:B WL[144]:B WL[145]:B WL[146]:B WL[147]:B
*.pininfo WL[148]:B WL[149]:B WL[150]:B WL[151]:B WL[152]:B WL[153]:B
*.pininfo WL[154]:B WL[155]:B WL[156]:B WL[157]:B WL[158]:B WL[159]:B
*.pininfo WL[160]:B WL[161]:B WL[162]:B WL[163]:B WL[164]:B WL[165]:B
*.pininfo WL[166]:B WL[167]:B WL[168]:B WL[169]:B WL[170]:B WL[171]:B
*.pininfo WL[172]:B WL[173]:B WL[174]:B WL[175]:B WL[176]:B WL[177]:B
*.pininfo WL[178]:B WL[179]:B WL[180]:B WL[181]:B WL[182]:B WL[183]:B
*.pininfo WL[184]:B WL[185]:B WL[186]:B WL[187]:B WL[188]:B WL[189]:B
*.pininfo WL[190]:B WL[191]:B WL[192]:B WL[193]:B WL[194]:B WL[195]:B
*.pininfo WL[196]:B WL[197]:B WL[198]:B WL[199]:B WL[200]:B WL[201]:B
*.pininfo WL[202]:B WL[203]:B WL[204]:B WL[205]:B WL[206]:B WL[207]:B
*.pininfo WL[208]:B WL[209]:B WL[210]:B WL[211]:B WL[212]:B WL[213]:B
*.pininfo WL[214]:B WL[215]:B WL[216]:B WL[217]:B WL[218]:B WL[219]:B
*.pininfo WL[220]:B WL[221]:B WL[222]:B WL[223]:B WL[224]:B WL[225]:B
*.pininfo WL[226]:B WL[227]:B WL[228]:B WL[229]:B WL[230]:B WL[231]:B
*.pininfo WL[232]:B WL[233]:B WL[234]:B WL[235]:B WL[236]:B WL[237]:B
*.pininfo WL[238]:B WL[239]:B WL[240]:B WL[241]:B WL[242]:B WL[243]:B
*.pininfo WL[244]:B WL[245]:B WL[246]:B WL[247]:B WL[248]:B WL[249]:B
*.pininfo WL[250]:B WL[251]:B WL[252]:B WL[253]:B WL[254]:B WL[255]:B VNW:B
*.pininfo VDDA:B PWR:B
XX00 VSSX RGD RGBW RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RBT[0] RBT[1] RBT[2]
+ RBT[3] RBT[4] RBT[5] RBT[6] RBT[7] RBT[8] RBT[9] RBT[10] RBT[11] RBT[12]
+ RBT[13] RBT[14] RBT[15] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGRD1[0]
+ RGRD1[1] RGRD1[2] RGRD1[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RBB[0]
+ RBB[1] RBB[2] RBB[3] RBB[4] RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10]
+ RBB[11] RBB[12] RBB[13] RBB[14] RBB[15] VSS VDDA PWR VNW WL[0] WL[1] WL[2]
+ WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] BB_TOP[0]
+ BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7]
+ BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14]
+ BB_TOP[15] VSS spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARE m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BA_RED

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_EDG_L VSSX VSS VDDA VNW
+ PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10]
+ WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+ WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30]
+ WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40]
+ WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50]
+ WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+ WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70]
+ WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80]
+ WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90]
+ WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100]
+ WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109]
+ WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118]
+ WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127]
+ WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136]
+ WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145]
+ WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154]
+ WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163]
+ WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172]
+ WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181]
+ WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190]
+ WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199]
+ WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208]
+ WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217]
+ WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226]
+ WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235]
+ WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244]
+ WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253]
+ WL[254] WL[255] RWL
*.pininfo VSSX:B VSS:B VDDA:B VNW:B PWR:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B
*.pininfo WL[4]:B WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B
*.pininfo WL[12]:B WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B
*.pininfo WL[19]:B WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B
*.pininfo WL[26]:B WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B
*.pininfo WL[33]:B WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B
*.pininfo WL[40]:B WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B
*.pininfo WL[47]:B WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B
*.pininfo WL[54]:B WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B
*.pininfo WL[61]:B WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B
*.pininfo WL[68]:B WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B
*.pininfo WL[75]:B WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B
*.pininfo WL[82]:B WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B
*.pininfo WL[89]:B WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B
*.pininfo WL[96]:B WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B
*.pininfo WL[103]:B WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B
*.pininfo WL[109]:B WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B
*.pininfo WL[115]:B WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B
*.pininfo WL[121]:B WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B
*.pininfo WL[127]:B WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B
*.pininfo WL[133]:B WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B
*.pininfo WL[139]:B WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B
*.pininfo WL[145]:B WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B
*.pininfo WL[151]:B WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B
*.pininfo WL[157]:B WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B
*.pininfo WL[163]:B WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B
*.pininfo WL[169]:B WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B
*.pininfo WL[175]:B WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B
*.pininfo WL[181]:B WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B
*.pininfo WL[187]:B WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B
*.pininfo WL[193]:B WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B
*.pininfo WL[199]:B WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B
*.pininfo WL[205]:B WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B
*.pininfo WL[211]:B WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B
*.pininfo WL[217]:B WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B
*.pininfo WL[223]:B WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B
*.pininfo WL[229]:B WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B
*.pininfo WL[235]:B WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B
*.pininfo WL[241]:B WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B
*.pininfo WL[247]:B WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B
*.pininfo WL[253]:B WL[254]:B WL[255]:B RWL:B
XXc0r0 PWR VDDA VNW VSS VSSX bitcell_edge_cap m=1
XXc1r0 PWR VDDA VNW VSS VSSX WL[0] WL[1] WL[2] WL[3] bitcell_edge m=1
XXc2r0 PWR VDDA VNW VSS VSSX WL[4] WL[5] WL[6] WL[7] bitcell_edge m=1
XXc3r0 PWR VDDA VNW VSS VSSX WL[8] WL[9] WL[10] WL[11] bitcell_edge m=1
XXc4r0 PWR VDDA VNW VSS VSSX WL[12] WL[13] WL[14] WL[15] bitcell_edge m=1
XXc5r0 PWR VDDA VNW VSS VSSX WL[16] WL[17] WL[18] WL[19] bitcell_edge m=1
XXc6r0 PWR VDDA VNW VSS VSSX WL[20] WL[21] WL[22] WL[23] bitcell_edge m=1
XXc7r0 PWR VDDA VNW VSS VSSX WL[24] WL[25] WL[26] WL[27] bitcell_edge m=1
XXc8r0 PWR VDDA VNW VSS VSSX WL[28] WL[29] WL[30] WL[31] bitcell_edge m=1
XXc9r0 PWR VDDA VNW VSS VSSX WL[32] WL[33] WL[34] WL[35] bitcell_edge m=1
XXc10r0 PWR VDDA VNW VSS VSSX WL[36] WL[37] WL[38] WL[39] bitcell_edge m=1
XXc11r0 PWR VDDA VNW VSS VSSX WL[40] WL[41] WL[42] WL[43] bitcell_edge m=1
XXc12r0 PWR VDDA VNW VSS VSSX WL[44] WL[45] WL[46] WL[47] bitcell_edge m=1
XXc13r0 PWR VDDA VNW VSS VSSX WL[48] WL[49] WL[50] WL[51] bitcell_edge m=1
XXc14r0 PWR VDDA VNW VSS VSSX WL[52] WL[53] WL[54] WL[55] bitcell_edge m=1
XXc15r0 PWR VDDA VNW VSS VSSX WL[56] WL[57] WL[58] WL[59] bitcell_edge m=1
XXc16r0 PWR VDDA VNW VSS VSSX WL[60] WL[61] WL[62] WL[63] bitcell_edge m=1
XXc17r0 PWR VDDA VNW VSS VSSX WL[64] WL[65] WL[66] WL[67] bitcell_edge m=1
XXc18r0 PWR VDDA VNW VSS VSSX WL[68] WL[69] WL[70] WL[71] bitcell_edge m=1
XXc19r0 PWR VDDA VNW VSS VSSX WL[72] WL[73] WL[74] WL[75] bitcell_edge m=1
XXc20r0 PWR VDDA VNW VSS VSSX WL[76] WL[77] WL[78] WL[79] bitcell_edge m=1
XXc21r0 PWR VDDA VNW VSS VSSX WL[80] WL[81] WL[82] WL[83] bitcell_edge m=1
XXc22r0 PWR VDDA VNW VSS VSSX WL[84] WL[85] WL[86] WL[87] bitcell_edge m=1
XXc23r0 PWR VDDA VNW VSS VSSX WL[88] WL[89] WL[90] WL[91] bitcell_edge m=1
XXc24r0 PWR VDDA VNW VSS VSSX WL[92] WL[93] WL[94] WL[95] bitcell_edge m=1
XXc25r0 PWR VDDA VNW VSS VSSX WL[96] WL[97] WL[98] WL[99] bitcell_edge m=1
XXc26r0 PWR VDDA VNW VSS VSSX WL[100] WL[101] WL[102] WL[103] bitcell_edge m=1
XXc27r0 PWR VDDA VNW VSS VSSX WL[104] WL[105] WL[106] WL[107] bitcell_edge m=1
XXc28r0 PWR VDDA VNW VSS VSSX WL[108] WL[109] WL[110] WL[111] bitcell_edge m=1
XXc29r0 PWR VDDA VNW VSS VSSX WL[112] WL[113] WL[114] WL[115] bitcell_edge m=1
XXc30r0 PWR VDDA VNW VSS VSSX WL[116] WL[117] WL[118] WL[119] bitcell_edge m=1
XXc31r0 PWR VDDA VNW VSS VSSX WL[120] WL[121] WL[122] WL[123] bitcell_edge m=1
XXc32r0 PWR VDDA VNW VSS VSSX WL[124] WL[125] WL[126] WL[127] bitcell_edge m=1
XXc33r0 PWR VDDA VNW VSS VSSX WL[128] WL[129] WL[130] WL[131] bitcell_edge m=1
XXc34r0 PWR VDDA VNW VSS VSSX WL[132] WL[133] WL[134] WL[135] bitcell_edge m=1
XXc35r0 PWR VDDA VNW VSS VSSX WL[136] WL[137] WL[138] WL[139] bitcell_edge m=1
XXc36r0 PWR VDDA VNW VSS VSSX WL[140] WL[141] WL[142] WL[143] bitcell_edge m=1
XXc37r0 PWR VDDA VNW VSS VSSX WL[144] WL[145] WL[146] WL[147] bitcell_edge m=1
XXc38r0 PWR VDDA VNW VSS VSSX WL[148] WL[149] WL[150] WL[151] bitcell_edge m=1
XXc39r0 PWR VDDA VNW VSS VSSX WL[152] WL[153] WL[154] WL[155] bitcell_edge m=1
XXc40r0 PWR VDDA VNW VSS VSSX WL[156] WL[157] WL[158] WL[159] bitcell_edge m=1
XXc41r0 PWR VDDA VNW VSS VSSX WL[160] WL[161] WL[162] WL[163] bitcell_edge m=1
XXc42r0 PWR VDDA VNW VSS VSSX WL[164] WL[165] WL[166] WL[167] bitcell_edge m=1
XXc43r0 PWR VDDA VNW VSS VSSX WL[168] WL[169] WL[170] WL[171] bitcell_edge m=1
XXc44r0 PWR VDDA VNW VSS VSSX WL[172] WL[173] WL[174] WL[175] bitcell_edge m=1
XXc45r0 PWR VDDA VNW VSS VSSX WL[176] WL[177] WL[178] WL[179] bitcell_edge m=1
XXc46r0 PWR VDDA VNW VSS VSSX WL[180] WL[181] WL[182] WL[183] bitcell_edge m=1
XXc47r0 PWR VDDA VNW VSS VSSX WL[184] WL[185] WL[186] WL[187] bitcell_edge m=1
XXc48r0 PWR VDDA VNW VSS VSSX WL[188] WL[189] WL[190] WL[191] bitcell_edge m=1
XXc49r0 PWR VDDA VNW VSS VSSX WL[192] WL[193] WL[194] WL[195] bitcell_edge m=1
XXc50r0 PWR VDDA VNW VSS VSSX WL[196] WL[197] WL[198] WL[199] bitcell_edge m=1
XXc51r0 PWR VDDA VNW VSS VSSX WL[200] WL[201] WL[202] WL[203] bitcell_edge m=1
XXc52r0 PWR VDDA VNW VSS VSSX WL[204] WL[205] WL[206] WL[207] bitcell_edge m=1
XXc53r0 PWR VDDA VNW VSS VSSX WL[208] WL[209] WL[210] WL[211] bitcell_edge m=1
XXc54r0 PWR VDDA VNW VSS VSSX WL[212] WL[213] WL[214] WL[215] bitcell_edge m=1
XXc55r0 PWR VDDA VNW VSS VSSX WL[216] WL[217] WL[218] WL[219] bitcell_edge m=1
XXc56r0 PWR VDDA VNW VSS VSSX WL[220] WL[221] WL[222] WL[223] bitcell_edge m=1
XXc57r0 PWR VDDA VNW VSS VSSX WL[224] WL[225] WL[226] WL[227] bitcell_edge m=1
XXc58r0 PWR VDDA VNW VSS VSSX WL[228] WL[229] WL[230] WL[231] bitcell_edge m=1
XXc59r0 PWR VDDA VNW VSS VSSX WL[232] WL[233] WL[234] WL[235] bitcell_edge m=1
XXc60r0 PWR VDDA VNW VSS VSSX WL[236] WL[237] WL[238] WL[239] bitcell_edge m=1
XXc61r0 PWR VDDA VNW VSS VSSX WL[240] WL[241] WL[242] WL[243] bitcell_edge m=1
XXc62r0 PWR VDDA VNW VSS VSSX WL[244] WL[245] WL[246] WL[247] bitcell_edge m=1
XXc63r0 PWR VDDA VNW VSS VSSX WL[248] WL[249] WL[250] WL[251] bitcell_edge m=1
XXc64r0 PWR VDDA VNW VSS VSSX WL[252] WL[253] WL[254] WL[255] bitcell_edge m=1
XXc65r0 PWR RWL VDDA VNW VSS VSSX bitcell_edge_tmr_wl m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_EDG_L

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGEL VSSX VSS VDDA RWL
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR
*.pininfo VSSX:B VSS:B VDDA:B RWL:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B
*.pininfo WL[5]:B WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B
*.pininfo WL[13]:B WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B
*.pininfo WL[20]:B WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B
*.pininfo WL[27]:B WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B
*.pininfo WL[34]:B WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B
*.pininfo WL[41]:B WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B
*.pininfo WL[48]:B WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B
*.pininfo WL[55]:B WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B
*.pininfo WL[62]:B WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B
*.pininfo WL[69]:B WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B
*.pininfo WL[76]:B WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B
*.pininfo WL[83]:B WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B
*.pininfo WL[90]:B WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B
*.pininfo WL[97]:B WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B
*.pininfo WL[104]:B WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B
*.pininfo WL[110]:B WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B
*.pininfo WL[116]:B WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B
*.pininfo WL[122]:B WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B
*.pininfo WL[128]:B WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B
*.pininfo WL[134]:B WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B
*.pininfo WL[140]:B WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B
*.pininfo WL[146]:B WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B
*.pininfo WL[152]:B WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B
*.pininfo WL[158]:B WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B
*.pininfo WL[164]:B WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B
*.pininfo WL[170]:B WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B
*.pininfo WL[176]:B WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B
*.pininfo WL[182]:B WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B
*.pininfo WL[188]:B WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B
*.pininfo WL[194]:B WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B
*.pininfo WL[200]:B WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B
*.pininfo WL[206]:B WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B
*.pininfo WL[212]:B WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B
*.pininfo WL[218]:B WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B
*.pininfo WL[224]:B WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B
*.pininfo WL[230]:B WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B
*.pininfo WL[236]:B WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B
*.pininfo WL[242]:B WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B
*.pininfo WL[248]:B WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B
*.pininfo WL[254]:B WL[255]:B VNW:B PWR:B
XX00 VSSX VSS VDDA VNW PWR WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7]
+ WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18]
+ WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28]
+ WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38]
+ WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48]
+ WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58]
+ WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68]
+ WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78]
+ WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88]
+ WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98]
+ WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105] WL[106] WL[107]
+ WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114] WL[115] WL[116]
+ WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123] WL[124] WL[125]
+ WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132] WL[133] WL[134]
+ WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141] WL[142] WL[143]
+ WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150] WL[151] WL[152]
+ WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159] WL[160] WL[161]
+ WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168] WL[169] WL[170]
+ WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177] WL[178] WL[179]
+ WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186] WL[187] WL[188]
+ WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195] WL[196] WL[197]
+ WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204] WL[205] WL[206]
+ WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213] WL[214] WL[215]
+ WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222] WL[223] WL[224]
+ WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231] WL[232] WL[233]
+ WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240] WL[241] WL[242]
+ WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249] WL[250] WL[251]
+ WL[252] WL[253] WL[254] WL[255] RWL
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_EDG_L m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGEL

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA VDDA VSS WL[0] WL[1] WL[2]
+ WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW PWR
+ VSSX RWL GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GBW[0] GBW[1]
+ GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12]
+ GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+ BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+ BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+ BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+ BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+ BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+ BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+ BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+ BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+ BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+ BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1]
+ BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+ BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+ BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+ BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53]
+ BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63]
+ BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+ BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83]
+ BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93]
+ BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+ BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112]
+ BT[113] BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121]
+ BT[122] BT[123] BT[124] BT[125] BT[126] BT[127] BB_TOP[0] BB_TOP[1]
+ BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8]
+ BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20] BB_TOP[21]
+ BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26] BB_TOP[27]
+ BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] BB_TOP[32] BB_TOP[33]
+ BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38] BB_TOP[39]
+ BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44] BB_TOP[45]
+ BB_TOP[46] BB_TOP[47] BB_TOP[48] BB_TOP[49] BB_TOP[50] BB_TOP[51]
+ BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55] BB_TOP[56] BB_TOP[57]
+ BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61] BB_TOP[62] BB_TOP[63]
+ BB_TOP[64] BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69]
+ BB_TOP[70] BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75]
+ BB_TOP[76] BB_TOP[77] BB_TOP[78] BB_TOP[79] BB_TOP[80] BB_TOP[81]
+ BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86] BB_TOP[87]
+ BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92] BB_TOP[93]
+ BB_TOP[94] BB_TOP[95] BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99]
+ BB_TOP[100] BB_TOP[101] BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105]
+ BB_TOP[106] BB_TOP[107] BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111]
+ BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115] BB_TOP[116] BB_TOP[117]
+ BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121] BB_TOP[122] BB_TOP[123]
+ BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127] RGD RGBW RGRD2[0] RGRD2[1]
+ RGRD2[2] RGRD2[3] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4] RBT[5] RBT[6] RBT[7]
+ RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14] RBT[15] RGRD3[0]
+ RGRD3[1] RGRD3[2] RGRD3[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RBB[0] RBB[1] RBB[2] RBB[3] RBB[4] RBB[5] RBB[6]
+ RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13] RBB[14] RBB[15]
+ BB_TOP[128] BB_TOP[129] BB_TOP[130] BB_TOP[131] BB_TOP[132] BB_TOP[133]
+ BB_TOP[134] BB_TOP[135] BB_TOP[136] BB_TOP[137] BB_TOP[138] BB_TOP[139]
+ BB_TOP[140] BB_TOP[141] BB_TOP[142] BB_TOP[143]
*.pininfo VDDA:B VSS:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B WL[5]:B
*.pininfo WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B WL[13]:B
*.pininfo WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B WL[20]:B
*.pininfo WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B WL[27]:B
*.pininfo WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B WL[34]:B
*.pininfo WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B WL[41]:B
*.pininfo WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B WL[48]:B
*.pininfo WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B WL[55]:B
*.pininfo WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B WL[62]:B
*.pininfo WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B WL[69]:B
*.pininfo WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B WL[76]:B
*.pininfo WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B WL[83]:B
*.pininfo WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B WL[90]:B
*.pininfo WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B WL[97]:B
*.pininfo WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B WL[104]:B
*.pininfo WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B WL[110]:B
*.pininfo WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B WL[116]:B
*.pininfo WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B WL[122]:B
*.pininfo WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B WL[128]:B
*.pininfo WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B WL[134]:B
*.pininfo WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B WL[140]:B
*.pininfo WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B WL[146]:B
*.pininfo WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B WL[152]:B
*.pininfo WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B WL[158]:B
*.pininfo WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B WL[164]:B
*.pininfo WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B WL[170]:B
*.pininfo WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B WL[176]:B
*.pininfo WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B WL[182]:B
*.pininfo WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B WL[188]:B
*.pininfo WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B WL[194]:B
*.pininfo WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B WL[200]:B
*.pininfo WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B WL[206]:B
*.pininfo WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B WL[212]:B
*.pininfo WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B WL[218]:B
*.pininfo WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B WL[224]:B
*.pininfo WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B WL[230]:B
*.pininfo WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B WL[236]:B
*.pininfo WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B WL[242]:B
*.pininfo WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B WL[248]:B
*.pininfo WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B WL[254]:B
*.pininfo WL[255]:B VNW:B PWR:B VSSX:B RWL:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B
*.pininfo GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B
*.pininfo GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B
*.pininfo GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B
*.pininfo GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B
*.pininfo GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B
*.pininfo GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B
*.pininfo GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B
*.pininfo GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B
*.pininfo GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B BB[0]:B
*.pininfo BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B BB[8]:B
*.pininfo BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B BB[15]:B
*.pininfo BB[16]:B BB[17]:B BB[18]:B BB[19]:B BB[20]:B BB[21]:B BB[22]:B
*.pininfo BB[23]:B BB[24]:B BB[25]:B BB[26]:B BB[27]:B BB[28]:B BB[29]:B
*.pininfo BB[30]:B BB[31]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B BB[36]:B
*.pininfo BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B BB[43]:B
*.pininfo BB[44]:B BB[45]:B BB[46]:B BB[47]:B BB[48]:B BB[49]:B BB[50]:B
*.pininfo BB[51]:B BB[52]:B BB[53]:B BB[54]:B BB[55]:B BB[56]:B BB[57]:B
*.pininfo BB[58]:B BB[59]:B BB[60]:B BB[61]:B BB[62]:B BB[63]:B BB[64]:B
*.pininfo BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B BB[71]:B
*.pininfo BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B BB[78]:B
*.pininfo BB[79]:B BB[80]:B BB[81]:B BB[82]:B BB[83]:B BB[84]:B BB[85]:B
*.pininfo BB[86]:B BB[87]:B BB[88]:B BB[89]:B BB[90]:B BB[91]:B BB[92]:B
*.pininfo BB[93]:B BB[94]:B BB[95]:B BB[96]:B BB[97]:B BB[98]:B BB[99]:B
*.pininfo BB[100]:B BB[101]:B BB[102]:B BB[103]:B BB[104]:B BB[105]:B
*.pininfo BB[106]:B BB[107]:B BB[108]:B BB[109]:B BB[110]:B BB[111]:B
*.pininfo BB[112]:B BB[113]:B BB[114]:B BB[115]:B BB[116]:B BB[117]:B
*.pininfo BB[118]:B BB[119]:B BB[120]:B BB[121]:B BB[122]:B BB[123]:B
*.pininfo BB[124]:B BB[125]:B BB[126]:B BB[127]:B BT[0]:B BT[1]:B BT[2]:B
*.pininfo BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B BT[9]:B BT[10]:B
*.pininfo BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B BT[16]:B BT[17]:B
*.pininfo BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B BT[23]:B BT[24]:B
*.pininfo BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B BT[30]:B BT[31]:B
*.pininfo BT[32]:B BT[33]:B BT[34]:B BT[35]:B BT[36]:B BT[37]:B BT[38]:B
*.pininfo BT[39]:B BT[40]:B BT[41]:B BT[42]:B BT[43]:B BT[44]:B BT[45]:B
*.pininfo BT[46]:B BT[47]:B BT[48]:B BT[49]:B BT[50]:B BT[51]:B BT[52]:B
*.pininfo BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B BT[58]:B BT[59]:B
*.pininfo BT[60]:B BT[61]:B BT[62]:B BT[63]:B BT[64]:B BT[65]:B BT[66]:B
*.pininfo BT[67]:B BT[68]:B BT[69]:B BT[70]:B BT[71]:B BT[72]:B BT[73]:B
*.pininfo BT[74]:B BT[75]:B BT[76]:B BT[77]:B BT[78]:B BT[79]:B BT[80]:B
*.pininfo BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B BT[86]:B BT[87]:B
*.pininfo BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B BT[93]:B BT[94]:B
*.pininfo BT[95]:B BT[96]:B BT[97]:B BT[98]:B BT[99]:B BT[100]:B BT[101]:B
*.pininfo BT[102]:B BT[103]:B BT[104]:B BT[105]:B BT[106]:B BT[107]:B
*.pininfo BT[108]:B BT[109]:B BT[110]:B BT[111]:B BT[112]:B BT[113]:B
*.pininfo BT[114]:B BT[115]:B BT[116]:B BT[117]:B BT[118]:B BT[119]:B
*.pininfo BT[120]:B BT[121]:B BT[122]:B BT[123]:B BT[124]:B BT[125]:B
*.pininfo BT[126]:B BT[127]:B BB_TOP[0]:B BB_TOP[1]:B BB_TOP[2]:B BB_TOP[3]:B
*.pininfo BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B BB_TOP[7]:B BB_TOP[8]:B
*.pininfo BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B BB_TOP[12]:B BB_TOP[13]:B
*.pininfo BB_TOP[14]:B BB_TOP[15]:B BB_TOP[16]:B BB_TOP[17]:B BB_TOP[18]:B
*.pininfo BB_TOP[19]:B BB_TOP[20]:B BB_TOP[21]:B BB_TOP[22]:B BB_TOP[23]:B
*.pininfo BB_TOP[24]:B BB_TOP[25]:B BB_TOP[26]:B BB_TOP[27]:B BB_TOP[28]:B
*.pininfo BB_TOP[29]:B BB_TOP[30]:B BB_TOP[31]:B BB_TOP[32]:B BB_TOP[33]:B
*.pininfo BB_TOP[34]:B BB_TOP[35]:B BB_TOP[36]:B BB_TOP[37]:B BB_TOP[38]:B
*.pininfo BB_TOP[39]:B BB_TOP[40]:B BB_TOP[41]:B BB_TOP[42]:B BB_TOP[43]:B
*.pininfo BB_TOP[44]:B BB_TOP[45]:B BB_TOP[46]:B BB_TOP[47]:B BB_TOP[48]:B
*.pininfo BB_TOP[49]:B BB_TOP[50]:B BB_TOP[51]:B BB_TOP[52]:B BB_TOP[53]:B
*.pininfo BB_TOP[54]:B BB_TOP[55]:B BB_TOP[56]:B BB_TOP[57]:B BB_TOP[58]:B
*.pininfo BB_TOP[59]:B BB_TOP[60]:B BB_TOP[61]:B BB_TOP[62]:B BB_TOP[63]:B
*.pininfo BB_TOP[64]:B BB_TOP[65]:B BB_TOP[66]:B BB_TOP[67]:B BB_TOP[68]:B
*.pininfo BB_TOP[69]:B BB_TOP[70]:B BB_TOP[71]:B BB_TOP[72]:B BB_TOP[73]:B
*.pininfo BB_TOP[74]:B BB_TOP[75]:B BB_TOP[76]:B BB_TOP[77]:B BB_TOP[78]:B
*.pininfo BB_TOP[79]:B BB_TOP[80]:B BB_TOP[81]:B BB_TOP[82]:B BB_TOP[83]:B
*.pininfo BB_TOP[84]:B BB_TOP[85]:B BB_TOP[86]:B BB_TOP[87]:B BB_TOP[88]:B
*.pininfo BB_TOP[89]:B BB_TOP[90]:B BB_TOP[91]:B BB_TOP[92]:B BB_TOP[93]:B
*.pininfo BB_TOP[94]:B BB_TOP[95]:B BB_TOP[96]:B BB_TOP[97]:B BB_TOP[98]:B
*.pininfo BB_TOP[99]:B BB_TOP[100]:B BB_TOP[101]:B BB_TOP[102]:B
*.pininfo BB_TOP[103]:B BB_TOP[104]:B BB_TOP[105]:B BB_TOP[106]:B
*.pininfo BB_TOP[107]:B BB_TOP[108]:B BB_TOP[109]:B BB_TOP[110]:B
*.pininfo BB_TOP[111]:B BB_TOP[112]:B BB_TOP[113]:B BB_TOP[114]:B
*.pininfo BB_TOP[115]:B BB_TOP[116]:B BB_TOP[117]:B BB_TOP[118]:B
*.pininfo BB_TOP[119]:B BB_TOP[120]:B BB_TOP[121]:B BB_TOP[122]:B
*.pininfo BB_TOP[123]:B BB_TOP[124]:B BB_TOP[125]:B BB_TOP[126]:B
*.pininfo BB_TOP[127]:B RGD:B RGBW:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B
*.pininfo RGRD2[3]:B RBT[0]:B RBT[1]:B RBT[2]:B RBT[3]:B RBT[4]:B RBT[5]:B
*.pininfo RBT[6]:B RBT[7]:B RBT[8]:B RBT[9]:B RBT[10]:B RBT[11]:B RBT[12]:B
*.pininfo RBT[13]:B RBT[14]:B RBT[15]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B
*.pininfo RGRD3[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD0[0]:B
*.pininfo RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B RBB[0]:B RBB[1]:B RBB[2]:B
*.pininfo RBB[3]:B RBB[4]:B RBB[5]:B RBB[6]:B RBB[7]:B RBB[8]:B RBB[9]:B
*.pininfo RBB[10]:B RBB[11]:B RBB[12]:B RBB[13]:B RBB[14]:B RBB[15]:B
*.pininfo BB_TOP[128]:B BB_TOP[129]:B BB_TOP[130]:B BB_TOP[131]:B
*.pininfo BB_TOP[132]:B BB_TOP[133]:B BB_TOP[134]:B BB_TOP[135]:B
*.pininfo BB_TOP[136]:B BB_TOP[137]:B BB_TOP[138]:B BB_TOP[139]:B
*.pininfo BB_TOP[140]:B BB_TOP[141]:B BB_TOP[142]:B BB_TOP[143]:B
XXspram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGER_0 VDDA VSSX VSS RWL
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGER m=1
XXspram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY_0 GD[0] GBW[0] VSSX
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD3[0] GRD3[1] GRD3[2] GRD3[3] BB[0] BB[1] BB[2]
+ BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+ BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] RWL BB_TOP[0] BB_TOP[1] BB_TOP[2]
+ BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8] BB_TOP[9]
+ BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15] WL[0]
+ WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+ WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+ WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+ WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+ WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+ WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+ WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72]
+ WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82]
+ WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92]
+ WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102]
+ WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111]
+ WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120]
+ WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129]
+ WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138]
+ WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147]
+ WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156]
+ WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165]
+ WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174]
+ WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183]
+ WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192]
+ WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201]
+ WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210]
+ WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219]
+ WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228]
+ WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237]
+ WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246]
+ WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW
+ VSS VDDA PWR GD[1] GBW[1] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+ BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18]
+ BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+ BT[29] BT[30] BT[31] BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20]
+ BB_TOP[21] BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26]
+ BB_TOP[27] BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] GD[2] GBW[2] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD3[8] GRD3[9] GRD3[10] GRD3[11] BB[32] BB[33] BB[34]
+ BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44]
+ BB[45] BB[46] BB[47] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38]
+ BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BB_TOP[32]
+ BB_TOP[33] BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38]
+ BB_TOP[39] BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44]
+ BB_TOP[45] BB_TOP[46] BB_TOP[47] GD[3] GBW[3] GRD0[12] GRD0[13] GRD0[14]
+ GRD0[15] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD3[12] GRD3[13] GRD3[14] GRD3[15] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+ BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BB_TOP[48]
+ BB_TOP[49] BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54]
+ BB_TOP[55] BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60]
+ BB_TOP[61] BB_TOP[62] BB_TOP[63] GD[4] GBW[4] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD3[16] GRD3[17] GRD3[18] GRD3[19] BB[64] BB[65] BB[66] BB[67]
+ BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77]
+ BB[78] BB[79] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71]
+ BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BB_TOP[64]
+ BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69] BB_TOP[70]
+ BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75] BB_TOP[76]
+ BB_TOP[77] BB_TOP[78] BB_TOP[79] GD[5] GBW[5] GRD0[20] GRD0[21] GRD0[22]
+ GRD0[23] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD3[20] GRD3[21] GRD3[22] GRD3[23] BB[80] BB[81] BB[82] BB[83]
+ BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+ BB[94] BB[95] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87]
+ BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BB_TOP[80]
+ BB_TOP[81] BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86]
+ BB_TOP[87] BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92]
+ BB_TOP[93] BB_TOP[94] BB_TOP[95] GD[6] GBW[6] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD3[24] GRD3[25] GRD3[26] GRD3[27] BB[96] BB[97] BB[98] BB[99]
+ BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+ BB[109] BB[110] BB[111] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102]
+ BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111]
+ BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101]
+ BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107]
+ BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111] GD[7] GBW[7] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[28]
+ GRD2[29] GRD2[30] GRD2[31] GRD3[28] GRD3[29] GRD3[30] GRD3[31] BB[112]
+ BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+ BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[112] BT[113] BT[114]
+ BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+ BT[124] BT[125] BT[126] BT[127] BB_TOP[112] BB_TOP[113] BB_TOP[114]
+ BB_TOP[115] BB_TOP[116] BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120]
+ BB_TOP[121] BB_TOP[122] BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126]
+ BB_TOP[127] spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BITARY m=1
XXspram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BA_RED_0 VSSX RGD RGBW RGRD2[0]
+ RGRD2[1] RGRD2[2] RGRD2[3] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4] RBT[5] RBT[6]
+ RBT[7] RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14] RBT[15]
+ RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3]
+ RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RBB[0] RBB[1] RBB[2] RBB[3] RBB[4]
+ RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13] RBB[14]
+ RBB[15] BB_TOP[128] BB_TOP[129] BB_TOP[130] BB_TOP[131] BB_TOP[132]
+ BB_TOP[133] BB_TOP[134] BB_TOP[135] BB_TOP[136] BB_TOP[137] BB_TOP[138]
+ BB_TOP[139] BB_TOP[140] BB_TOP[141] BB_TOP[142] BB_TOP[143] VSS WL[0] WL[1]
+ WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW VDDA
+ PWR spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_BA_RED m=1
XXspram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGEL_0 VSSX VSS VDDA RWL
+ WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11]
+ WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21]
+ WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+ WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41]
+ WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51]
+ WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61]
+ WL[62] WL[63] WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71]
+ WL[72] WL[73] WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81]
+ WL[82] WL[83] WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91]
+ WL[92] WL[93] WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101]
+ WL[102] WL[103] WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110]
+ WL[111] WL[112] WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119]
+ WL[120] WL[121] WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128]
+ WL[129] WL[130] WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137]
+ WL[138] WL[139] WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146]
+ WL[147] WL[148] WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155]
+ WL[156] WL[157] WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164]
+ WL[165] WL[166] WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173]
+ WL[174] WL[175] WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182]
+ WL[183] WL[184] WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191]
+ WL[192] WL[193] WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200]
+ WL[201] WL[202] WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209]
+ WL[210] WL[211] WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218]
+ WL[219] WL[220] WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227]
+ WL[228] WL[229] WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236]
+ WL[237] WL[238] WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245]
+ WL[246] WL[247] WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254]
+ WL[255] VNW PWR spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_ARYEDGEL m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA

.subckt spram_4096x16m16b1pm2re1RE1M16_B1TOP VSS VDDA WL[0] WL[1] WL[2] WL[3]
+ WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14]
+ WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24]
+ WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34]
+ WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44]
+ WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54]
+ WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64]
+ WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74]
+ WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84]
+ WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94]
+ WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104]
+ WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113]
+ WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122]
+ WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131]
+ WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140]
+ WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149]
+ WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158]
+ WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167]
+ WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176]
+ WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185]
+ WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194]
+ WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203]
+ WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212]
+ WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221]
+ WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230]
+ WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239]
+ WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248]
+ WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW PWR BB[0] BB[1]
+ BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+ BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23]
+ BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33]
+ BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+ BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+ BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63]
+ BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73]
+ BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83]
+ BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+ BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+ BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112]
+ BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+ BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3]
+ BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+ BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+ BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+ BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+ BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+ BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+ BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74]
+ BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+ BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+ BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104]
+ BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113]
+ BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122]
+ BT[123] BT[124] BT[125] BT[126] BT[127] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4]
+ GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8]
+ GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16]
+ GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24]
+ GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0]
+ GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9]
+ GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17]
+ GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25]
+ GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1]
+ GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10]
+ GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18]
+ GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26]
+ GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2]
+ GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11]
+ GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19]
+ GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27]
+ GRD3[28] GRD3[29] GRD3[30] GRD3[31] RBB[0] RBB[1] RBB[2] RBB[3] RBB[4]
+ RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13] RBB[14]
+ RBB[15] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4] RBT[5] RBT[6] RBT[7] RBT[8]
+ RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14] RBT[15] RGRD0[0] RGRD0[1]
+ RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1]
+ RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] VSSX RGD RGBW
+ BB_TOP[0] BB_TOP[1] BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6]
+ BB_TOP[7] BB_TOP[8] BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13]
+ BB_TOP[14] BB_TOP[15] BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19]
+ BB_TOP[20] BB_TOP[21] BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25]
+ BB_TOP[26] BB_TOP[27] BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31]
+ BB_TOP[32] BB_TOP[33] BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37]
+ BB_TOP[38] BB_TOP[39] BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43]
+ BB_TOP[44] BB_TOP[45] BB_TOP[46] BB_TOP[47] BB_TOP[48] BB_TOP[49]
+ BB_TOP[50] BB_TOP[51] BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55]
+ BB_TOP[56] BB_TOP[57] BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61]
+ BB_TOP[62] BB_TOP[63] BB_TOP[64] BB_TOP[65] BB_TOP[66] BB_TOP[67]
+ BB_TOP[68] BB_TOP[69] BB_TOP[70] BB_TOP[71] BB_TOP[72] BB_TOP[73]
+ BB_TOP[74] BB_TOP[75] BB_TOP[76] BB_TOP[77] BB_TOP[78] BB_TOP[79]
+ BB_TOP[80] BB_TOP[81] BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85]
+ BB_TOP[86] BB_TOP[87] BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91]
+ BB_TOP[92] BB_TOP[93] BB_TOP[94] BB_TOP[95] BB_TOP[96] BB_TOP[97]
+ BB_TOP[98] BB_TOP[99] BB_TOP[100] BB_TOP[101] BB_TOP[102] BB_TOP[103]
+ BB_TOP[104] BB_TOP[105] BB_TOP[106] BB_TOP[107] BB_TOP[108] BB_TOP[109]
+ BB_TOP[110] BB_TOP[111] BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115]
+ BB_TOP[116] BB_TOP[117] BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121]
+ BB_TOP[122] BB_TOP[123] BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127]
+ BB_TOP[128] BB_TOP[129] BB_TOP[130] BB_TOP[131] BB_TOP[132] BB_TOP[133]
+ BB_TOP[134] BB_TOP[135] BB_TOP[136] BB_TOP[137] BB_TOP[138] BB_TOP[139]
+ BB_TOP[140] BB_TOP[141] BB_TOP[142] BB_TOP[143] RWL
*.pininfo VSS:B VDDA:B WL[0]:B WL[1]:B WL[2]:B WL[3]:B WL[4]:B WL[5]:B
*.pininfo WL[6]:B WL[7]:B WL[8]:B WL[9]:B WL[10]:B WL[11]:B WL[12]:B WL[13]:B
*.pininfo WL[14]:B WL[15]:B WL[16]:B WL[17]:B WL[18]:B WL[19]:B WL[20]:B
*.pininfo WL[21]:B WL[22]:B WL[23]:B WL[24]:B WL[25]:B WL[26]:B WL[27]:B
*.pininfo WL[28]:B WL[29]:B WL[30]:B WL[31]:B WL[32]:B WL[33]:B WL[34]:B
*.pininfo WL[35]:B WL[36]:B WL[37]:B WL[38]:B WL[39]:B WL[40]:B WL[41]:B
*.pininfo WL[42]:B WL[43]:B WL[44]:B WL[45]:B WL[46]:B WL[47]:B WL[48]:B
*.pininfo WL[49]:B WL[50]:B WL[51]:B WL[52]:B WL[53]:B WL[54]:B WL[55]:B
*.pininfo WL[56]:B WL[57]:B WL[58]:B WL[59]:B WL[60]:B WL[61]:B WL[62]:B
*.pininfo WL[63]:B WL[64]:B WL[65]:B WL[66]:B WL[67]:B WL[68]:B WL[69]:B
*.pininfo WL[70]:B WL[71]:B WL[72]:B WL[73]:B WL[74]:B WL[75]:B WL[76]:B
*.pininfo WL[77]:B WL[78]:B WL[79]:B WL[80]:B WL[81]:B WL[82]:B WL[83]:B
*.pininfo WL[84]:B WL[85]:B WL[86]:B WL[87]:B WL[88]:B WL[89]:B WL[90]:B
*.pininfo WL[91]:B WL[92]:B WL[93]:B WL[94]:B WL[95]:B WL[96]:B WL[97]:B
*.pininfo WL[98]:B WL[99]:B WL[100]:B WL[101]:B WL[102]:B WL[103]:B WL[104]:B
*.pininfo WL[105]:B WL[106]:B WL[107]:B WL[108]:B WL[109]:B WL[110]:B
*.pininfo WL[111]:B WL[112]:B WL[113]:B WL[114]:B WL[115]:B WL[116]:B
*.pininfo WL[117]:B WL[118]:B WL[119]:B WL[120]:B WL[121]:B WL[122]:B
*.pininfo WL[123]:B WL[124]:B WL[125]:B WL[126]:B WL[127]:B WL[128]:B
*.pininfo WL[129]:B WL[130]:B WL[131]:B WL[132]:B WL[133]:B WL[134]:B
*.pininfo WL[135]:B WL[136]:B WL[137]:B WL[138]:B WL[139]:B WL[140]:B
*.pininfo WL[141]:B WL[142]:B WL[143]:B WL[144]:B WL[145]:B WL[146]:B
*.pininfo WL[147]:B WL[148]:B WL[149]:B WL[150]:B WL[151]:B WL[152]:B
*.pininfo WL[153]:B WL[154]:B WL[155]:B WL[156]:B WL[157]:B WL[158]:B
*.pininfo WL[159]:B WL[160]:B WL[161]:B WL[162]:B WL[163]:B WL[164]:B
*.pininfo WL[165]:B WL[166]:B WL[167]:B WL[168]:B WL[169]:B WL[170]:B
*.pininfo WL[171]:B WL[172]:B WL[173]:B WL[174]:B WL[175]:B WL[176]:B
*.pininfo WL[177]:B WL[178]:B WL[179]:B WL[180]:B WL[181]:B WL[182]:B
*.pininfo WL[183]:B WL[184]:B WL[185]:B WL[186]:B WL[187]:B WL[188]:B
*.pininfo WL[189]:B WL[190]:B WL[191]:B WL[192]:B WL[193]:B WL[194]:B
*.pininfo WL[195]:B WL[196]:B WL[197]:B WL[198]:B WL[199]:B WL[200]:B
*.pininfo WL[201]:B WL[202]:B WL[203]:B WL[204]:B WL[205]:B WL[206]:B
*.pininfo WL[207]:B WL[208]:B WL[209]:B WL[210]:B WL[211]:B WL[212]:B
*.pininfo WL[213]:B WL[214]:B WL[215]:B WL[216]:B WL[217]:B WL[218]:B
*.pininfo WL[219]:B WL[220]:B WL[221]:B WL[222]:B WL[223]:B WL[224]:B
*.pininfo WL[225]:B WL[226]:B WL[227]:B WL[228]:B WL[229]:B WL[230]:B
*.pininfo WL[231]:B WL[232]:B WL[233]:B WL[234]:B WL[235]:B WL[236]:B
*.pininfo WL[237]:B WL[238]:B WL[239]:B WL[240]:B WL[241]:B WL[242]:B
*.pininfo WL[243]:B WL[244]:B WL[245]:B WL[246]:B WL[247]:B WL[248]:B
*.pininfo WL[249]:B WL[250]:B WL[251]:B WL[252]:B WL[253]:B WL[254]:B
*.pininfo WL[255]:B VNW:B PWR:B BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B
*.pininfo BB[5]:B BB[6]:B BB[7]:B BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B
*.pininfo BB[13]:B BB[14]:B BB[15]:B BB[16]:B BB[17]:B BB[18]:B BB[19]:B
*.pininfo BB[20]:B BB[21]:B BB[22]:B BB[23]:B BB[24]:B BB[25]:B BB[26]:B
*.pininfo BB[27]:B BB[28]:B BB[29]:B BB[30]:B BB[31]:B BB[32]:B BB[33]:B
*.pininfo BB[34]:B BB[35]:B BB[36]:B BB[37]:B BB[38]:B BB[39]:B BB[40]:B
*.pininfo BB[41]:B BB[42]:B BB[43]:B BB[44]:B BB[45]:B BB[46]:B BB[47]:B
*.pininfo BB[48]:B BB[49]:B BB[50]:B BB[51]:B BB[52]:B BB[53]:B BB[54]:B
*.pininfo BB[55]:B BB[56]:B BB[57]:B BB[58]:B BB[59]:B BB[60]:B BB[61]:B
*.pininfo BB[62]:B BB[63]:B BB[64]:B BB[65]:B BB[66]:B BB[67]:B BB[68]:B
*.pininfo BB[69]:B BB[70]:B BB[71]:B BB[72]:B BB[73]:B BB[74]:B BB[75]:B
*.pininfo BB[76]:B BB[77]:B BB[78]:B BB[79]:B BB[80]:B BB[81]:B BB[82]:B
*.pininfo BB[83]:B BB[84]:B BB[85]:B BB[86]:B BB[87]:B BB[88]:B BB[89]:B
*.pininfo BB[90]:B BB[91]:B BB[92]:B BB[93]:B BB[94]:B BB[95]:B BB[96]:B
*.pininfo BB[97]:B BB[98]:B BB[99]:B BB[100]:B BB[101]:B BB[102]:B BB[103]:B
*.pininfo BB[104]:B BB[105]:B BB[106]:B BB[107]:B BB[108]:B BB[109]:B
*.pininfo BB[110]:B BB[111]:B BB[112]:B BB[113]:B BB[114]:B BB[115]:B
*.pininfo BB[116]:B BB[117]:B BB[118]:B BB[119]:B BB[120]:B BB[121]:B
*.pininfo BB[122]:B BB[123]:B BB[124]:B BB[125]:B BB[126]:B BB[127]:B BT[0]:B
*.pininfo BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B
*.pininfo BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B
*.pininfo BT[16]:B BT[17]:B BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B
*.pininfo BT[23]:B BT[24]:B BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B
*.pininfo BT[30]:B BT[31]:B BT[32]:B BT[33]:B BT[34]:B BT[35]:B BT[36]:B
*.pininfo BT[37]:B BT[38]:B BT[39]:B BT[40]:B BT[41]:B BT[42]:B BT[43]:B
*.pininfo BT[44]:B BT[45]:B BT[46]:B BT[47]:B BT[48]:B BT[49]:B BT[50]:B
*.pininfo BT[51]:B BT[52]:B BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B
*.pininfo BT[58]:B BT[59]:B BT[60]:B BT[61]:B BT[62]:B BT[63]:B BT[64]:B
*.pininfo BT[65]:B BT[66]:B BT[67]:B BT[68]:B BT[69]:B BT[70]:B BT[71]:B
*.pininfo BT[72]:B BT[73]:B BT[74]:B BT[75]:B BT[76]:B BT[77]:B BT[78]:B
*.pininfo BT[79]:B BT[80]:B BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B
*.pininfo BT[86]:B BT[87]:B BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B
*.pininfo BT[93]:B BT[94]:B BT[95]:B BT[96]:B BT[97]:B BT[98]:B BT[99]:B
*.pininfo BT[100]:B BT[101]:B BT[102]:B BT[103]:B BT[104]:B BT[105]:B
*.pininfo BT[106]:B BT[107]:B BT[108]:B BT[109]:B BT[110]:B BT[111]:B
*.pininfo BT[112]:B BT[113]:B BT[114]:B BT[115]:B BT[116]:B BT[117]:B
*.pininfo BT[118]:B BT[119]:B BT[120]:B BT[121]:B BT[122]:B BT[123]:B
*.pininfo BT[124]:B BT[125]:B BT[126]:B BT[127]:B GBW[0]:B GBW[1]:B GBW[2]:B
*.pininfo GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B
*.pininfo GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B
*.pininfo GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B
*.pininfo GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B
*.pininfo GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B
*.pininfo GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B
*.pininfo GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B
*.pininfo GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B
*.pininfo GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B
*.pininfo GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B
*.pininfo GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B
*.pininfo GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B
*.pininfo GRD1[30]:B GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B
*.pininfo GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B
*.pininfo GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B
*.pininfo GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B
*.pininfo GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B
*.pininfo GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B
*.pininfo GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B
*.pininfo GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B
*.pininfo GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B
*.pininfo GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B
*.pininfo GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B
*.pininfo RBB[0]:B RBB[1]:B RBB[2]:B RBB[3]:B RBB[4]:B RBB[5]:B RBB[6]:B
*.pininfo RBB[7]:B RBB[8]:B RBB[9]:B RBB[10]:B RBB[11]:B RBB[12]:B RBB[13]:B
*.pininfo RBB[14]:B RBB[15]:B RBT[0]:B RBT[1]:B RBT[2]:B RBT[3]:B RBT[4]:B
*.pininfo RBT[5]:B RBT[6]:B RBT[7]:B RBT[8]:B RBT[9]:B RBT[10]:B RBT[11]:B
*.pininfo RBT[12]:B RBT[13]:B RBT[14]:B RBT[15]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B
*.pininfo RGRD3[2]:B RGRD3[3]:B VSSX:B RGD:B RGBW:B BB_TOP[0]:B BB_TOP[1]:B
*.pininfo BB_TOP[2]:B BB_TOP[3]:B BB_TOP[4]:B BB_TOP[5]:B BB_TOP[6]:B
*.pininfo BB_TOP[7]:B BB_TOP[8]:B BB_TOP[9]:B BB_TOP[10]:B BB_TOP[11]:B
*.pininfo BB_TOP[12]:B BB_TOP[13]:B BB_TOP[14]:B BB_TOP[15]:B BB_TOP[16]:B
*.pininfo BB_TOP[17]:B BB_TOP[18]:B BB_TOP[19]:B BB_TOP[20]:B BB_TOP[21]:B
*.pininfo BB_TOP[22]:B BB_TOP[23]:B BB_TOP[24]:B BB_TOP[25]:B BB_TOP[26]:B
*.pininfo BB_TOP[27]:B BB_TOP[28]:B BB_TOP[29]:B BB_TOP[30]:B BB_TOP[31]:B
*.pininfo BB_TOP[32]:B BB_TOP[33]:B BB_TOP[34]:B BB_TOP[35]:B BB_TOP[36]:B
*.pininfo BB_TOP[37]:B BB_TOP[38]:B BB_TOP[39]:B BB_TOP[40]:B BB_TOP[41]:B
*.pininfo BB_TOP[42]:B BB_TOP[43]:B BB_TOP[44]:B BB_TOP[45]:B BB_TOP[46]:B
*.pininfo BB_TOP[47]:B BB_TOP[48]:B BB_TOP[49]:B BB_TOP[50]:B BB_TOP[51]:B
*.pininfo BB_TOP[52]:B BB_TOP[53]:B BB_TOP[54]:B BB_TOP[55]:B BB_TOP[56]:B
*.pininfo BB_TOP[57]:B BB_TOP[58]:B BB_TOP[59]:B BB_TOP[60]:B BB_TOP[61]:B
*.pininfo BB_TOP[62]:B BB_TOP[63]:B BB_TOP[64]:B BB_TOP[65]:B BB_TOP[66]:B
*.pininfo BB_TOP[67]:B BB_TOP[68]:B BB_TOP[69]:B BB_TOP[70]:B BB_TOP[71]:B
*.pininfo BB_TOP[72]:B BB_TOP[73]:B BB_TOP[74]:B BB_TOP[75]:B BB_TOP[76]:B
*.pininfo BB_TOP[77]:B BB_TOP[78]:B BB_TOP[79]:B BB_TOP[80]:B BB_TOP[81]:B
*.pininfo BB_TOP[82]:B BB_TOP[83]:B BB_TOP[84]:B BB_TOP[85]:B BB_TOP[86]:B
*.pininfo BB_TOP[87]:B BB_TOP[88]:B BB_TOP[89]:B BB_TOP[90]:B BB_TOP[91]:B
*.pininfo BB_TOP[92]:B BB_TOP[93]:B BB_TOP[94]:B BB_TOP[95]:B BB_TOP[96]:B
*.pininfo BB_TOP[97]:B BB_TOP[98]:B BB_TOP[99]:B BB_TOP[100]:B BB_TOP[101]:B
*.pininfo BB_TOP[102]:B BB_TOP[103]:B BB_TOP[104]:B BB_TOP[105]:B
*.pininfo BB_TOP[106]:B BB_TOP[107]:B BB_TOP[108]:B BB_TOP[109]:B
*.pininfo BB_TOP[110]:B BB_TOP[111]:B BB_TOP[112]:B BB_TOP[113]:B
*.pininfo BB_TOP[114]:B BB_TOP[115]:B BB_TOP[116]:B BB_TOP[117]:B
*.pininfo BB_TOP[118]:B BB_TOP[119]:B BB_TOP[120]:B BB_TOP[121]:B
*.pininfo BB_TOP[122]:B BB_TOP[123]:B BB_TOP[124]:B BB_TOP[125]:B
*.pininfo BB_TOP[126]:B BB_TOP[127]:B BB_TOP[128]:B BB_TOP[129]:B
*.pininfo BB_TOP[130]:B BB_TOP[131]:B BB_TOP[132]:B BB_TOP[133]:B
*.pininfo BB_TOP[134]:B BB_TOP[135]:B BB_TOP[136]:B BB_TOP[137]:B
*.pininfo BB_TOP[138]:B BB_TOP[139]:B BB_TOP[140]:B BB_TOP[141]:B
*.pininfo BB_TOP[142]:B BB_TOP[143]:B RWL:B
XXspram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA_0 VDDA VSS WL[0] WL[1] WL[2]
+ WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+ WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+ WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+ WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+ WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+ WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+ WL[64] WL[65] WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73]
+ WL[74] WL[75] WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83]
+ WL[84] WL[85] WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93]
+ WL[94] WL[95] WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103]
+ WL[104] WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112]
+ WL[113] WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121]
+ WL[122] WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130]
+ WL[131] WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139]
+ WL[140] WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148]
+ WL[149] WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157]
+ WL[158] WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166]
+ WL[167] WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175]
+ WL[176] WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184]
+ WL[185] WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193]
+ WL[194] WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202]
+ WL[203] WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211]
+ WL[212] WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220]
+ WL[221] WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229]
+ WL[230] WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238]
+ WL[239] WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247]
+ WL[248] WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] VNW PWR
+ VSSX RWL GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GBW[0] GBW[1]
+ GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3]
+ GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12]
+ GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20]
+ GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28]
+ GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5]
+ GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13]
+ GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21]
+ GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29]
+ GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6]
+ GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14]
+ GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22]
+ GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30]
+ GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7]
+ GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15]
+ GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23]
+ GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31]
+ BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+ BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+ BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+ BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+ BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+ BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+ BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+ BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+ BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+ BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+ BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+ BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+ BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1]
+ BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+ BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+ BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+ BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+ BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53]
+ BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63]
+ BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+ BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83]
+ BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93]
+ BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+ BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112]
+ BT[113] BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121]
+ BT[122] BT[123] BT[124] BT[125] BT[126] BT[127] BB_TOP[0] BB_TOP[1]
+ BB_TOP[2] BB_TOP[3] BB_TOP[4] BB_TOP[5] BB_TOP[6] BB_TOP[7] BB_TOP[8]
+ BB_TOP[9] BB_TOP[10] BB_TOP[11] BB_TOP[12] BB_TOP[13] BB_TOP[14] BB_TOP[15]
+ BB_TOP[16] BB_TOP[17] BB_TOP[18] BB_TOP[19] BB_TOP[20] BB_TOP[21]
+ BB_TOP[22] BB_TOP[23] BB_TOP[24] BB_TOP[25] BB_TOP[26] BB_TOP[27]
+ BB_TOP[28] BB_TOP[29] BB_TOP[30] BB_TOP[31] BB_TOP[32] BB_TOP[33]
+ BB_TOP[34] BB_TOP[35] BB_TOP[36] BB_TOP[37] BB_TOP[38] BB_TOP[39]
+ BB_TOP[40] BB_TOP[41] BB_TOP[42] BB_TOP[43] BB_TOP[44] BB_TOP[45]
+ BB_TOP[46] BB_TOP[47] BB_TOP[48] BB_TOP[49] BB_TOP[50] BB_TOP[51]
+ BB_TOP[52] BB_TOP[53] BB_TOP[54] BB_TOP[55] BB_TOP[56] BB_TOP[57]
+ BB_TOP[58] BB_TOP[59] BB_TOP[60] BB_TOP[61] BB_TOP[62] BB_TOP[63]
+ BB_TOP[64] BB_TOP[65] BB_TOP[66] BB_TOP[67] BB_TOP[68] BB_TOP[69]
+ BB_TOP[70] BB_TOP[71] BB_TOP[72] BB_TOP[73] BB_TOP[74] BB_TOP[75]
+ BB_TOP[76] BB_TOP[77] BB_TOP[78] BB_TOP[79] BB_TOP[80] BB_TOP[81]
+ BB_TOP[82] BB_TOP[83] BB_TOP[84] BB_TOP[85] BB_TOP[86] BB_TOP[87]
+ BB_TOP[88] BB_TOP[89] BB_TOP[90] BB_TOP[91] BB_TOP[92] BB_TOP[93]
+ BB_TOP[94] BB_TOP[95] BB_TOP[96] BB_TOP[97] BB_TOP[98] BB_TOP[99]
+ BB_TOP[100] BB_TOP[101] BB_TOP[102] BB_TOP[103] BB_TOP[104] BB_TOP[105]
+ BB_TOP[106] BB_TOP[107] BB_TOP[108] BB_TOP[109] BB_TOP[110] BB_TOP[111]
+ BB_TOP[112] BB_TOP[113] BB_TOP[114] BB_TOP[115] BB_TOP[116] BB_TOP[117]
+ BB_TOP[118] BB_TOP[119] BB_TOP[120] BB_TOP[121] BB_TOP[122] BB_TOP[123]
+ BB_TOP[124] BB_TOP[125] BB_TOP[126] BB_TOP[127] RGD RGBW RGRD2[0] RGRD2[1]
+ RGRD2[2] RGRD2[3] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4] RBT[5] RBT[6] RBT[7]
+ RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14] RBT[15] RGRD3[0]
+ RGRD3[1] RGRD3[2] RGRD3[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RBB[0] RBB[1] RBB[2] RBB[3] RBB[4] RBB[5] RBB[6]
+ RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13] RBB[14] RBB[15]
+ BB_TOP[128] BB_TOP[129] BB_TOP[130] BB_TOP[131] BB_TOP[132] BB_TOP[133]
+ BB_TOP[134] BB_TOP[135] BB_TOP[136] BB_TOP[137] BB_TOP[138] BB_TOP[139]
+ BB_TOP[140] BB_TOP[141] BB_TOP[142] BB_TOP[143]
+ spram_4096x16m16b1pm2re1RE1M16_B1TOPARRAYA m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1TOP

.subckt spram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_L BB[128] BB[129]
+ BB[130] BB[131] BB[132] BB[133] BB[134] BB[135] BB[136] BB[137] BB[138]
+ BB[139] BB[140] BB[141] BB[142] BB[143] BB[144] BB[145] BB[146] BB[147]
+ BB[148] BB[149] BB[150] BB[151] BB[152] BB[153] BB[154] BB[155] BB[156]
+ BB[157] BB[158] BB[159] BB[160] BB[161] BB[162] BB[163] BB[164] BB[165]
+ BB[166] BB[167] BB[168] BB[169] BB[170] BB[171] BB[172] BB[173] BB[174]
+ BB[175] BB[176] BB[177] BB[178] BB[179] BB[180] BB[181] BB[182] BB[183]
+ BB[184] BB[185] BB[186] BB[187] BB[188] BB[189] BB[190] BB[191] BB[192]
+ BB[193] BB[194] BB[195] BB[196] BB[197] BB[198] BB[199] BB[200] BB[201]
+ BB[202] BB[203] BB[204] BB[205] BB[206] BB[207] BB[208] BB[209] BB[210]
+ BB[211] BB[212] BB[213] BB[214] BB[215] BB[216] BB[217] BB[218] BB[219]
+ BB[220] BB[221] BB[222] BB[223] BB[224] BB[225] BB[226] BB[227] BB[228]
+ BB[229] BB[230] BB[231] BB[232] BB[233] BB[234] BB[235] BB[236] BB[237]
+ BB[238] BB[239] BB[240] BB[241] BB[242] BB[243] BB[244] BB[245] BB[246]
+ BB[247] BB[248] BB[249] BB[250] BB[251] BB[252] BB[253] BB[254] BB[255]
+ BT[128] BT[129] BT[130] BT[131] BT[132] BT[133] BT[134] BT[135] BT[136]
+ BT[137] BT[138] BT[139] BT[140] BT[141] BT[142] BT[143] BT[144] BT[145]
+ BT[146] BT[147] BT[148] BT[149] BT[150] BT[151] BT[152] BT[153] BT[154]
+ BT[155] BT[156] BT[157] BT[158] BT[159] BT[160] BT[161] BT[162] BT[163]
+ BT[164] BT[165] BT[166] BT[167] BT[168] BT[169] BT[170] BT[171] BT[172]
+ BT[173] BT[174] BT[175] BT[176] BT[177] BT[178] BT[179] BT[180] BT[181]
+ BT[182] BT[183] BT[184] BT[185] BT[186] BT[187] BT[188] BT[189] BT[190]
+ BT[191] BT[192] BT[193] BT[194] BT[195] BT[196] BT[197] BT[198] BT[199]
+ BT[200] BT[201] BT[202] BT[203] BT[204] BT[205] BT[206] BT[207] BT[208]
+ BT[209] BT[210] BT[211] BT[212] BT[213] BT[214] BT[215] BT[216] BT[217]
+ BT[218] BT[219] BT[220] BT[221] BT[222] BT[223] BT[224] BT[225] BT[226]
+ BT[227] BT[228] BT[229] BT[230] BT[231] BT[232] BT[233] BT[234] BT[235]
+ BT[236] BT[237] BT[238] BT[239] BT[240] BT[241] BT[242] BT[243] BT[244]
+ BT[245] BT[246] BT[247] BT[248] BT[249] BT[250] BT[251] BT[252] BT[253]
+ BT[254] BT[255] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14]
+ GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32]
+ GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40]
+ GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48]
+ GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56]
+ GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32]
+ GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40]
+ GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48]
+ GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56]
+ GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32]
+ GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40]
+ GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48]
+ GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56]
+ GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32]
+ GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40]
+ GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48]
+ GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56]
+ GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] RBB[0]
+ RBB[1] RBB[2] RBB[3] RBB[4] RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10]
+ RBB[11] RBB[12] RBB[13] RBB[14] RBB[15] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4]
+ RBT[5] RBT[6] RBT[7] RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14]
+ RBT[15] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2]
+ RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2]
+ RGRD3[3] VSS VSSX VDDA RGD RGBW WLC[0] WLC[1] WLC[2] WLC[3] WLC[4] WLC[5]
+ WLC[6] WLC[7] WLC[8] WLC[9] WLC[10] WLC[11] WLC[12] WLC[13] WLC[14] WLC[15]
+ WLC[16] WLC[17] WLC[18] WLC[19] WLC[20] WLC[21] WLC[22] WLC[23] WLC[24]
+ WLC[25] WLC[26] WLC[27] WLC[28] WLC[29] WLC[30] WLC[31] WLC[32] WLC[33]
+ WLC[34] WLC[35] WLC[36] WLC[37] WLC[38] WLC[39] WLC[40] WLC[41] WLC[42]
+ WLC[43] WLC[44] WLC[45] WLC[46] WLC[47] WLC[48] WLC[49] WLC[50] WLC[51]
+ WLC[52] WLC[53] WLC[54] WLC[55] WLC[56] WLC[57] WLC[58] WLC[59] WLC[60]
+ WLC[61] WLC[62] WLC[63] WLC[64] WLC[65] WLC[66] WLC[67] WLC[68] WLC[69]
+ WLC[70] WLC[71] WLC[72] WLC[73] WLC[74] WLC[75] WLC[76] WLC[77] WLC[78]
+ WLC[79] WLC[80] WLC[81] WLC[82] WLC[83] WLC[84] WLC[85] WLC[86] WLC[87]
+ WLC[88] WLC[89] WLC[90] WLC[91] WLC[92] WLC[93] WLC[94] WLC[95] WLC[96]
+ WLC[97] WLC[98] WLC[99] WLC[100] WLC[101] WLC[102] WLC[103] WLC[104]
+ WLC[105] WLC[106] WLC[107] WLC[108] WLC[109] WLC[110] WLC[111] WLC[112]
+ WLC[113] WLC[114] WLC[115] WLC[116] WLC[117] WLC[118] WLC[119] WLC[120]
+ WLC[121] WLC[122] WLC[123] WLC[124] WLC[125] WLC[126] WLC[127] WLC[128]
+ WLC[129] WLC[130] WLC[131] WLC[132] WLC[133] WLC[134] WLC[135] WLC[136]
+ WLC[137] WLC[138] WLC[139] WLC[140] WLC[141] WLC[142] WLC[143] WLC[144]
+ WLC[145] WLC[146] WLC[147] WLC[148] WLC[149] WLC[150] WLC[151] WLC[152]
+ WLC[153] WLC[154] WLC[155] WLC[156] WLC[157] WLC[158] WLC[159] WLC[160]
+ WLC[161] WLC[162] WLC[163] WLC[164] WLC[165] WLC[166] WLC[167] WLC[168]
+ WLC[169] WLC[170] WLC[171] WLC[172] WLC[173] WLC[174] WLC[175] WLC[176]
+ WLC[177] WLC[178] WLC[179] WLC[180] WLC[181] WLC[182] WLC[183] WLC[184]
+ WLC[185] WLC[186] WLC[187] WLC[188] WLC[189] WLC[190] WLC[191] WLC[192]
+ WLC[193] WLC[194] WLC[195] WLC[196] WLC[197] WLC[198] WLC[199] WLC[200]
+ WLC[201] WLC[202] WLC[203] WLC[204] WLC[205] WLC[206] WLC[207] WLC[208]
+ WLC[209] WLC[210] WLC[211] WLC[212] WLC[213] WLC[214] WLC[215] WLC[216]
+ WLC[217] WLC[218] WLC[219] WLC[220] WLC[221] WLC[222] WLC[223] WLC[224]
+ WLC[225] WLC[226] WLC[227] WLC[228] WLC[229] WLC[230] WLC[231] WLC[232]
+ WLC[233] WLC[234] WLC[235] WLC[236] WLC[237] WLC[238] WLC[239] WLC[240]
+ WLC[241] WLC[242] WLC[243] WLC[244] WLC[245] WLC[246] WLC[247] WLC[248]
+ WLC[249] WLC[250] WLC[251] WLC[252] WLC[253] WLC[254] WLC[255] VNW PWR
*.pininfo BB[128]:B BB[129]:B BB[130]:B BB[131]:B BB[132]:B BB[133]:B
*.pininfo BB[134]:B BB[135]:B BB[136]:B BB[137]:B BB[138]:B BB[139]:B
*.pininfo BB[140]:B BB[141]:B BB[142]:B BB[143]:B BB[144]:B BB[145]:B
*.pininfo BB[146]:B BB[147]:B BB[148]:B BB[149]:B BB[150]:B BB[151]:B
*.pininfo BB[152]:B BB[153]:B BB[154]:B BB[155]:B BB[156]:B BB[157]:B
*.pininfo BB[158]:B BB[159]:B BB[160]:B BB[161]:B BB[162]:B BB[163]:B
*.pininfo BB[164]:B BB[165]:B BB[166]:B BB[167]:B BB[168]:B BB[169]:B
*.pininfo BB[170]:B BB[171]:B BB[172]:B BB[173]:B BB[174]:B BB[175]:B
*.pininfo BB[176]:B BB[177]:B BB[178]:B BB[179]:B BB[180]:B BB[181]:B
*.pininfo BB[182]:B BB[183]:B BB[184]:B BB[185]:B BB[186]:B BB[187]:B
*.pininfo BB[188]:B BB[189]:B BB[190]:B BB[191]:B BB[192]:B BB[193]:B
*.pininfo BB[194]:B BB[195]:B BB[196]:B BB[197]:B BB[198]:B BB[199]:B
*.pininfo BB[200]:B BB[201]:B BB[202]:B BB[203]:B BB[204]:B BB[205]:B
*.pininfo BB[206]:B BB[207]:B BB[208]:B BB[209]:B BB[210]:B BB[211]:B
*.pininfo BB[212]:B BB[213]:B BB[214]:B BB[215]:B BB[216]:B BB[217]:B
*.pininfo BB[218]:B BB[219]:B BB[220]:B BB[221]:B BB[222]:B BB[223]:B
*.pininfo BB[224]:B BB[225]:B BB[226]:B BB[227]:B BB[228]:B BB[229]:B
*.pininfo BB[230]:B BB[231]:B BB[232]:B BB[233]:B BB[234]:B BB[235]:B
*.pininfo BB[236]:B BB[237]:B BB[238]:B BB[239]:B BB[240]:B BB[241]:B
*.pininfo BB[242]:B BB[243]:B BB[244]:B BB[245]:B BB[246]:B BB[247]:B
*.pininfo BB[248]:B BB[249]:B BB[250]:B BB[251]:B BB[252]:B BB[253]:B
*.pininfo BB[254]:B BB[255]:B BT[128]:B BT[129]:B BT[130]:B BT[131]:B
*.pininfo BT[132]:B BT[133]:B BT[134]:B BT[135]:B BT[136]:B BT[137]:B
*.pininfo BT[138]:B BT[139]:B BT[140]:B BT[141]:B BT[142]:B BT[143]:B
*.pininfo BT[144]:B BT[145]:B BT[146]:B BT[147]:B BT[148]:B BT[149]:B
*.pininfo BT[150]:B BT[151]:B BT[152]:B BT[153]:B BT[154]:B BT[155]:B
*.pininfo BT[156]:B BT[157]:B BT[158]:B BT[159]:B BT[160]:B BT[161]:B
*.pininfo BT[162]:B BT[163]:B BT[164]:B BT[165]:B BT[166]:B BT[167]:B
*.pininfo BT[168]:B BT[169]:B BT[170]:B BT[171]:B BT[172]:B BT[173]:B
*.pininfo BT[174]:B BT[175]:B BT[176]:B BT[177]:B BT[178]:B BT[179]:B
*.pininfo BT[180]:B BT[181]:B BT[182]:B BT[183]:B BT[184]:B BT[185]:B
*.pininfo BT[186]:B BT[187]:B BT[188]:B BT[189]:B BT[190]:B BT[191]:B
*.pininfo BT[192]:B BT[193]:B BT[194]:B BT[195]:B BT[196]:B BT[197]:B
*.pininfo BT[198]:B BT[199]:B BT[200]:B BT[201]:B BT[202]:B BT[203]:B
*.pininfo BT[204]:B BT[205]:B BT[206]:B BT[207]:B BT[208]:B BT[209]:B
*.pininfo BT[210]:B BT[211]:B BT[212]:B BT[213]:B BT[214]:B BT[215]:B
*.pininfo BT[216]:B BT[217]:B BT[218]:B BT[219]:B BT[220]:B BT[221]:B
*.pininfo BT[222]:B BT[223]:B BT[224]:B BT[225]:B BT[226]:B BT[227]:B
*.pininfo BT[228]:B BT[229]:B BT[230]:B BT[231]:B BT[232]:B BT[233]:B
*.pininfo BT[234]:B BT[235]:B BT[236]:B BT[237]:B BT[238]:B BT[239]:B
*.pininfo BT[240]:B BT[241]:B BT[242]:B BT[243]:B BT[244]:B BT[245]:B
*.pininfo BT[246]:B BT[247]:B BT[248]:B BT[249]:B BT[250]:B BT[251]:B
*.pininfo BT[252]:B BT[253]:B BT[254]:B BT[255]:B GBW[8]:B GBW[9]:B GBW[10]:B
*.pininfo GBW[11]:B GBW[12]:B GBW[13]:B GBW[14]:B GBW[15]:B GD[8]:B GD[9]:B
*.pininfo GD[10]:B GD[11]:B GD[12]:B GD[13]:B GD[14]:B GD[15]:B GRD0[32]:B
*.pininfo GRD0[33]:B GRD0[34]:B GRD0[35]:B GRD0[36]:B GRD0[37]:B GRD0[38]:B
*.pininfo GRD0[39]:B GRD0[40]:B GRD0[41]:B GRD0[42]:B GRD0[43]:B GRD0[44]:B
*.pininfo GRD0[45]:B GRD0[46]:B GRD0[47]:B GRD0[48]:B GRD0[49]:B GRD0[50]:B
*.pininfo GRD0[51]:B GRD0[52]:B GRD0[53]:B GRD0[54]:B GRD0[55]:B GRD0[56]:B
*.pininfo GRD0[57]:B GRD0[58]:B GRD0[59]:B GRD0[60]:B GRD0[61]:B GRD0[62]:B
*.pininfo GRD0[63]:B GRD1[32]:B GRD1[33]:B GRD1[34]:B GRD1[35]:B GRD1[36]:B
*.pininfo GRD1[37]:B GRD1[38]:B GRD1[39]:B GRD1[40]:B GRD1[41]:B GRD1[42]:B
*.pininfo GRD1[43]:B GRD1[44]:B GRD1[45]:B GRD1[46]:B GRD1[47]:B GRD1[48]:B
*.pininfo GRD1[49]:B GRD1[50]:B GRD1[51]:B GRD1[52]:B GRD1[53]:B GRD1[54]:B
*.pininfo GRD1[55]:B GRD1[56]:B GRD1[57]:B GRD1[58]:B GRD1[59]:B GRD1[60]:B
*.pininfo GRD1[61]:B GRD1[62]:B GRD1[63]:B GRD2[32]:B GRD2[33]:B GRD2[34]:B
*.pininfo GRD2[35]:B GRD2[36]:B GRD2[37]:B GRD2[38]:B GRD2[39]:B GRD2[40]:B
*.pininfo GRD2[41]:B GRD2[42]:B GRD2[43]:B GRD2[44]:B GRD2[45]:B GRD2[46]:B
*.pininfo GRD2[47]:B GRD2[48]:B GRD2[49]:B GRD2[50]:B GRD2[51]:B GRD2[52]:B
*.pininfo GRD2[53]:B GRD2[54]:B GRD2[55]:B GRD2[56]:B GRD2[57]:B GRD2[58]:B
*.pininfo GRD2[59]:B GRD2[60]:B GRD2[61]:B GRD2[62]:B GRD2[63]:B GRD3[32]:B
*.pininfo GRD3[33]:B GRD3[34]:B GRD3[35]:B GRD3[36]:B GRD3[37]:B GRD3[38]:B
*.pininfo GRD3[39]:B GRD3[40]:B GRD3[41]:B GRD3[42]:B GRD3[43]:B GRD3[44]:B
*.pininfo GRD3[45]:B GRD3[46]:B GRD3[47]:B GRD3[48]:B GRD3[49]:B GRD3[50]:B
*.pininfo GRD3[51]:B GRD3[52]:B GRD3[53]:B GRD3[54]:B GRD3[55]:B GRD3[56]:B
*.pininfo GRD3[57]:B GRD3[58]:B GRD3[59]:B GRD3[60]:B GRD3[61]:B GRD3[62]:B
*.pininfo GRD3[63]:B RBB[0]:B RBB[1]:B RBB[2]:B RBB[3]:B RBB[4]:B RBB[5]:B
*.pininfo RBB[6]:B RBB[7]:B RBB[8]:B RBB[9]:B RBB[10]:B RBB[11]:B RBB[12]:B
*.pininfo RBB[13]:B RBB[14]:B RBB[15]:B RBT[0]:B RBT[1]:B RBT[2]:B RBT[3]:B
*.pininfo RBT[4]:B RBT[5]:B RBT[6]:B RBT[7]:B RBT[8]:B RBT[9]:B RBT[10]:B
*.pininfo RBT[11]:B RBT[12]:B RBT[13]:B RBT[14]:B RBT[15]:B RGRD0[0]:B
*.pininfo RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B
*.pininfo RGRD1[3]:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B
*.pininfo RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B VSS:B VSSX:B VDDA:B RGD:B RGBW:B
*.pininfo WLC[0]:B WLC[1]:B WLC[2]:B WLC[3]:B WLC[4]:B WLC[5]:B WLC[6]:B
*.pininfo WLC[7]:B WLC[8]:B WLC[9]:B WLC[10]:B WLC[11]:B WLC[12]:B WLC[13]:B
*.pininfo WLC[14]:B WLC[15]:B WLC[16]:B WLC[17]:B WLC[18]:B WLC[19]:B
*.pininfo WLC[20]:B WLC[21]:B WLC[22]:B WLC[23]:B WLC[24]:B WLC[25]:B
*.pininfo WLC[26]:B WLC[27]:B WLC[28]:B WLC[29]:B WLC[30]:B WLC[31]:B
*.pininfo WLC[32]:B WLC[33]:B WLC[34]:B WLC[35]:B WLC[36]:B WLC[37]:B
*.pininfo WLC[38]:B WLC[39]:B WLC[40]:B WLC[41]:B WLC[42]:B WLC[43]:B
*.pininfo WLC[44]:B WLC[45]:B WLC[46]:B WLC[47]:B WLC[48]:B WLC[49]:B
*.pininfo WLC[50]:B WLC[51]:B WLC[52]:B WLC[53]:B WLC[54]:B WLC[55]:B
*.pininfo WLC[56]:B WLC[57]:B WLC[58]:B WLC[59]:B WLC[60]:B WLC[61]:B
*.pininfo WLC[62]:B WLC[63]:B WLC[64]:B WLC[65]:B WLC[66]:B WLC[67]:B
*.pininfo WLC[68]:B WLC[69]:B WLC[70]:B WLC[71]:B WLC[72]:B WLC[73]:B
*.pininfo WLC[74]:B WLC[75]:B WLC[76]:B WLC[77]:B WLC[78]:B WLC[79]:B
*.pininfo WLC[80]:B WLC[81]:B WLC[82]:B WLC[83]:B WLC[84]:B WLC[85]:B
*.pininfo WLC[86]:B WLC[87]:B WLC[88]:B WLC[89]:B WLC[90]:B WLC[91]:B
*.pininfo WLC[92]:B WLC[93]:B WLC[94]:B WLC[95]:B WLC[96]:B WLC[97]:B
*.pininfo WLC[98]:B WLC[99]:B WLC[100]:B WLC[101]:B WLC[102]:B WLC[103]:B
*.pininfo WLC[104]:B WLC[105]:B WLC[106]:B WLC[107]:B WLC[108]:B WLC[109]:B
*.pininfo WLC[110]:B WLC[111]:B WLC[112]:B WLC[113]:B WLC[114]:B WLC[115]:B
*.pininfo WLC[116]:B WLC[117]:B WLC[118]:B WLC[119]:B WLC[120]:B WLC[121]:B
*.pininfo WLC[122]:B WLC[123]:B WLC[124]:B WLC[125]:B WLC[126]:B WLC[127]:B
*.pininfo WLC[128]:B WLC[129]:B WLC[130]:B WLC[131]:B WLC[132]:B WLC[133]:B
*.pininfo WLC[134]:B WLC[135]:B WLC[136]:B WLC[137]:B WLC[138]:B WLC[139]:B
*.pininfo WLC[140]:B WLC[141]:B WLC[142]:B WLC[143]:B WLC[144]:B WLC[145]:B
*.pininfo WLC[146]:B WLC[147]:B WLC[148]:B WLC[149]:B WLC[150]:B WLC[151]:B
*.pininfo WLC[152]:B WLC[153]:B WLC[154]:B WLC[155]:B WLC[156]:B WLC[157]:B
*.pininfo WLC[158]:B WLC[159]:B WLC[160]:B WLC[161]:B WLC[162]:B WLC[163]:B
*.pininfo WLC[164]:B WLC[165]:B WLC[166]:B WLC[167]:B WLC[168]:B WLC[169]:B
*.pininfo WLC[170]:B WLC[171]:B WLC[172]:B WLC[173]:B WLC[174]:B WLC[175]:B
*.pininfo WLC[176]:B WLC[177]:B WLC[178]:B WLC[179]:B WLC[180]:B WLC[181]:B
*.pininfo WLC[182]:B WLC[183]:B WLC[184]:B WLC[185]:B WLC[186]:B WLC[187]:B
*.pininfo WLC[188]:B WLC[189]:B WLC[190]:B WLC[191]:B WLC[192]:B WLC[193]:B
*.pininfo WLC[194]:B WLC[195]:B WLC[196]:B WLC[197]:B WLC[198]:B WLC[199]:B
*.pininfo WLC[200]:B WLC[201]:B WLC[202]:B WLC[203]:B WLC[204]:B WLC[205]:B
*.pininfo WLC[206]:B WLC[207]:B WLC[208]:B WLC[209]:B WLC[210]:B WLC[211]:B
*.pininfo WLC[212]:B WLC[213]:B WLC[214]:B WLC[215]:B WLC[216]:B WLC[217]:B
*.pininfo WLC[218]:B WLC[219]:B WLC[220]:B WLC[221]:B WLC[222]:B WLC[223]:B
*.pininfo WLC[224]:B WLC[225]:B WLC[226]:B WLC[227]:B WLC[228]:B WLC[229]:B
*.pininfo WLC[230]:B WLC[231]:B WLC[232]:B WLC[233]:B WLC[234]:B WLC[235]:B
*.pininfo WLC[236]:B WLC[237]:B WLC[238]:B WLC[239]:B WLC[240]:B WLC[241]:B
*.pininfo WLC[242]:B WLC[243]:B WLC[244]:B WLC[245]:B WLC[246]:B WLC[247]:B
*.pininfo WLC[248]:B WLC[249]:B WLC[250]:B WLC[251]:B WLC[252]:B WLC[253]:B
*.pininfo WLC[254]:B WLC[255]:B VNW:B PWR:B
XXSBNK_BITARY_L VSS VDDA WLC[0] WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6]
+ WLC[7] WLC[8] WLC[9] WLC[10] WLC[11] WLC[12] WLC[13] WLC[14] WLC[15]
+ WLC[16] WLC[17] WLC[18] WLC[19] WLC[20] WLC[21] WLC[22] WLC[23] WLC[24]
+ WLC[25] WLC[26] WLC[27] WLC[28] WLC[29] WLC[30] WLC[31] WLC[32] WLC[33]
+ WLC[34] WLC[35] WLC[36] WLC[37] WLC[38] WLC[39] WLC[40] WLC[41] WLC[42]
+ WLC[43] WLC[44] WLC[45] WLC[46] WLC[47] WLC[48] WLC[49] WLC[50] WLC[51]
+ WLC[52] WLC[53] WLC[54] WLC[55] WLC[56] WLC[57] WLC[58] WLC[59] WLC[60]
+ WLC[61] WLC[62] WLC[63] WLC[64] WLC[65] WLC[66] WLC[67] WLC[68] WLC[69]
+ WLC[70] WLC[71] WLC[72] WLC[73] WLC[74] WLC[75] WLC[76] WLC[77] WLC[78]
+ WLC[79] WLC[80] WLC[81] WLC[82] WLC[83] WLC[84] WLC[85] WLC[86] WLC[87]
+ WLC[88] WLC[89] WLC[90] WLC[91] WLC[92] WLC[93] WLC[94] WLC[95] WLC[96]
+ WLC[97] WLC[98] WLC[99] WLC[100] WLC[101] WLC[102] WLC[103] WLC[104]
+ WLC[105] WLC[106] WLC[107] WLC[108] WLC[109] WLC[110] WLC[111] WLC[112]
+ WLC[113] WLC[114] WLC[115] WLC[116] WLC[117] WLC[118] WLC[119] WLC[120]
+ WLC[121] WLC[122] WLC[123] WLC[124] WLC[125] WLC[126] WLC[127] WLC[128]
+ WLC[129] WLC[130] WLC[131] WLC[132] WLC[133] WLC[134] WLC[135] WLC[136]
+ WLC[137] WLC[138] WLC[139] WLC[140] WLC[141] WLC[142] WLC[143] WLC[144]
+ WLC[145] WLC[146] WLC[147] WLC[148] WLC[149] WLC[150] WLC[151] WLC[152]
+ WLC[153] WLC[154] WLC[155] WLC[156] WLC[157] WLC[158] WLC[159] WLC[160]
+ WLC[161] WLC[162] WLC[163] WLC[164] WLC[165] WLC[166] WLC[167] WLC[168]
+ WLC[169] WLC[170] WLC[171] WLC[172] WLC[173] WLC[174] WLC[175] WLC[176]
+ WLC[177] WLC[178] WLC[179] WLC[180] WLC[181] WLC[182] WLC[183] WLC[184]
+ WLC[185] WLC[186] WLC[187] WLC[188] WLC[189] WLC[190] WLC[191] WLC[192]
+ WLC[193] WLC[194] WLC[195] WLC[196] WLC[197] WLC[198] WLC[199] WLC[200]
+ WLC[201] WLC[202] WLC[203] WLC[204] WLC[205] WLC[206] WLC[207] WLC[208]
+ WLC[209] WLC[210] WLC[211] WLC[212] WLC[213] WLC[214] WLC[215] WLC[216]
+ WLC[217] WLC[218] WLC[219] WLC[220] WLC[221] WLC[222] WLC[223] WLC[224]
+ WLC[225] WLC[226] WLC[227] WLC[228] WLC[229] WLC[230] WLC[231] WLC[232]
+ WLC[233] WLC[234] WLC[235] WLC[236] WLC[237] WLC[238] WLC[239] WLC[240]
+ WLC[241] WLC[242] WLC[243] WLC[244] WLC[245] WLC[246] WLC[247] WLC[248]
+ WLC[249] WLC[250] WLC[251] WLC[252] WLC[253] WLC[254] WLC[255] VNW PWR
+ BB[128] BB[129] BB[130] BB[131] BB[132] BB[133] BB[134] BB[135] BB[136]
+ BB[137] BB[138] BB[139] BB[140] BB[141] BB[142] BB[143] BB[144] BB[145]
+ BB[146] BB[147] BB[148] BB[149] BB[150] BB[151] BB[152] BB[153] BB[154]
+ BB[155] BB[156] BB[157] BB[158] BB[159] BB[160] BB[161] BB[162] BB[163]
+ BB[164] BB[165] BB[166] BB[167] BB[168] BB[169] BB[170] BB[171] BB[172]
+ BB[173] BB[174] BB[175] BB[176] BB[177] BB[178] BB[179] BB[180] BB[181]
+ BB[182] BB[183] BB[184] BB[185] BB[186] BB[187] BB[188] BB[189] BB[190]
+ BB[191] BB[192] BB[193] BB[194] BB[195] BB[196] BB[197] BB[198] BB[199]
+ BB[200] BB[201] BB[202] BB[203] BB[204] BB[205] BB[206] BB[207] BB[208]
+ BB[209] BB[210] BB[211] BB[212] BB[213] BB[214] BB[215] BB[216] BB[217]
+ BB[218] BB[219] BB[220] BB[221] BB[222] BB[223] BB[224] BB[225] BB[226]
+ BB[227] BB[228] BB[229] BB[230] BB[231] BB[232] BB[233] BB[234] BB[235]
+ BB[236] BB[237] BB[238] BB[239] BB[240] BB[241] BB[242] BB[243] BB[244]
+ BB[245] BB[246] BB[247] BB[248] BB[249] BB[250] BB[251] BB[252] BB[253]
+ BB[254] BB[255] BT[128] BT[129] BT[130] BT[131] BT[132] BT[133] BT[134]
+ BT[135] BT[136] BT[137] BT[138] BT[139] BT[140] BT[141] BT[142] BT[143]
+ BT[144] BT[145] BT[146] BT[147] BT[148] BT[149] BT[150] BT[151] BT[152]
+ BT[153] BT[154] BT[155] BT[156] BT[157] BT[158] BT[159] BT[160] BT[161]
+ BT[162] BT[163] BT[164] BT[165] BT[166] BT[167] BT[168] BT[169] BT[170]
+ BT[171] BT[172] BT[173] BT[174] BT[175] BT[176] BT[177] BT[178] BT[179]
+ BT[180] BT[181] BT[182] BT[183] BT[184] BT[185] BT[186] BT[187] BT[188]
+ BT[189] BT[190] BT[191] BT[192] BT[193] BT[194] BT[195] BT[196] BT[197]
+ BT[198] BT[199] BT[200] BT[201] BT[202] BT[203] BT[204] BT[205] BT[206]
+ BT[207] BT[208] BT[209] BT[210] BT[211] BT[212] BT[213] BT[214] BT[215]
+ BT[216] BT[217] BT[218] BT[219] BT[220] BT[221] BT[222] BT[223] BT[224]
+ BT[225] BT[226] BT[227] BT[228] BT[229] BT[230] BT[231] BT[232] BT[233]
+ BT[234] BT[235] BT[236] BT[237] BT[238] BT[239] BT[240] BT[241] BT[242]
+ BT[243] BT[244] BT[245] BT[246] BT[247] BT[248] BT[249] BT[250] BT[251]
+ BT[252] BT[253] BT[254] BT[255] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12]
+ GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14]
+ GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37] GRD0[38]
+ GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45] GRD0[46]
+ GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53] GRD0[54]
+ GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61] GRD0[62]
+ GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38]
+ GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46]
+ GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54]
+ GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62]
+ GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38]
+ GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46]
+ GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54]
+ GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62]
+ GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] RBB[0] RBB[1] RBB[2] RBB[3] RBB[4] RBB[5] RBB[6] RBB[7] RBB[8]
+ RBB[9] RBB[10] RBB[11] RBB[12] RBB[13] RBB[14] RBB[15] RBT[0] RBT[1] RBT[2]
+ RBT[3] RBT[4] RBT[5] RBT[6] RBT[7] RBT[8] RBT[9] RBT[10] RBT[11] RBT[12]
+ RBT[13] RBT[14] RBT[15] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0]
+ RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0]
+ RGRD3[1] RGRD3[2] RGRD3[3] VSSX RGD RGBW VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX VSSX
+ VSSX VSSX VSS spram_4096x16m16b1pm2re1RE1M16_B1TOP m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_L

.subckt spram_4096x16m16b1pm2re1RE1M16_B1SBNK BB[0] BB[1] BB[2] BB[3] BB[4]
+ BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15]
+ BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25]
+ BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35]
+ BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45]
+ BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55]
+ BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65]
+ BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75]
+ BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85]
+ BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+ BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+ BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+ BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+ BB[124] BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6]
+ BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17]
+ BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27]
+ BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37]
+ BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47]
+ BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+ BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67]
+ BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77]
+ BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87]
+ BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97]
+ BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106]
+ BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115]
+ BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124]
+ BT[125] BT[126] BT[127] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6]
+ GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] VSS VSSX VDDA PD[0] PD[1] PD[2] PD[3] RWL DBL CSH_YS[0] CSH_YS[1]
+ CSH_YS[2] CSH_YS[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] QT[0] QT[1] QT[2] QT[3]
+ QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] RMO[0] RMO[1] RMO[2]
+ VSB[0] VSB[1] VSB[2] VSB[3] WMO[0] WMO[1] WMO[2] XARLSBA[0] XARLSBA[1]
+ XARLSBA[2] XARLSBA[3] XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3]
+ XARMSBB[0] XARMSBB[1] XARMSBB[2] XARMSBB[3] CSH_ENB BPUI SPUI ZRR VNW DBL0
+ LCLKB PWR ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT BB[128] BB[129] BB[130]
+ BB[131] BB[132] BB[133] BB[134] BB[135] BB[136] BB[137] BB[138] BB[139]
+ BB[140] BB[141] BB[142] BB[143] BB[144] BB[145] BB[146] BB[147] BB[148]
+ BB[149] BB[150] BB[151] BB[152] BB[153] BB[154] BB[155] BB[156] BB[157]
+ BB[158] BB[159] BB[160] BB[161] BB[162] BB[163] BB[164] BB[165] BB[166]
+ BB[167] BB[168] BB[169] BB[170] BB[171] BB[172] BB[173] BB[174] BB[175]
+ BB[176] BB[177] BB[178] BB[179] BB[180] BB[181] BB[182] BB[183] BB[184]
+ BB[185] BB[186] BB[187] BB[188] BB[189] BB[190] BB[191] BB[192] BB[193]
+ BB[194] BB[195] BB[196] BB[197] BB[198] BB[199] BB[200] BB[201] BB[202]
+ BB[203] BB[204] BB[205] BB[206] BB[207] BB[208] BB[209] BB[210] BB[211]
+ BB[212] BB[213] BB[214] BB[215] BB[216] BB[217] BB[218] BB[219] BB[220]
+ BB[221] BB[222] BB[223] BB[224] BB[225] BB[226] BB[227] BB[228] BB[229]
+ BB[230] BB[231] BB[232] BB[233] BB[234] BB[235] BB[236] BB[237] BB[238]
+ BB[239] BB[240] BB[241] BB[242] BB[243] BB[244] BB[245] BB[246] BB[247]
+ BB[248] BB[249] BB[250] BB[251] BB[252] BB[253] BB[254] BB[255] BT[128]
+ BT[129] BT[130] BT[131] BT[132] BT[133] BT[134] BT[135] BT[136] BT[137]
+ BT[138] BT[139] BT[140] BT[141] BT[142] BT[143] BT[144] BT[145] BT[146]
+ BT[147] BT[148] BT[149] BT[150] BT[151] BT[152] BT[153] BT[154] BT[155]
+ BT[156] BT[157] BT[158] BT[159] BT[160] BT[161] BT[162] BT[163] BT[164]
+ BT[165] BT[166] BT[167] BT[168] BT[169] BT[170] BT[171] BT[172] BT[173]
+ BT[174] BT[175] BT[176] BT[177] BT[178] BT[179] BT[180] BT[181] BT[182]
+ BT[183] BT[184] BT[185] BT[186] BT[187] BT[188] BT[189] BT[190] BT[191]
+ BT[192] BT[193] BT[194] BT[195] BT[196] BT[197] BT[198] BT[199] BT[200]
+ BT[201] BT[202] BT[203] BT[204] BT[205] BT[206] BT[207] BT[208] BT[209]
+ BT[210] BT[211] BT[212] BT[213] BT[214] BT[215] BT[216] BT[217] BT[218]
+ BT[219] BT[220] BT[221] BT[222] BT[223] BT[224] BT[225] BT[226] BT[227]
+ BT[228] BT[229] BT[230] BT[231] BT[232] BT[233] BT[234] BT[235] BT[236]
+ BT[237] BT[238] BT[239] BT[240] BT[241] BT[242] BT[243] BT[244] BT[245]
+ BT[246] BT[247] BT[248] BT[249] BT[250] BT[251] BT[252] BT[253] BT[254]
+ BT[255] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8]
+ GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34]
+ GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42]
+ GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50]
+ GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58]
+ GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34]
+ GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42]
+ GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50]
+ GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58]
+ GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34]
+ GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42]
+ GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50]
+ GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58]
+ GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] RBB[0] RBB[1] RBB[2] RBB[3]
+ RBB[4] RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13]
+ RBB[14] RBB[15] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4] RBT[5] RBT[6] RBT[7]
+ RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14] RBT[15] RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0]
+ RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGD RGBW
*.pininfo BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.pininfo BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.pininfo BB[15]:B BB[16]:B BB[17]:B BB[18]:B BB[19]:B BB[20]:B BB[21]:B
*.pininfo BB[22]:B BB[23]:B BB[24]:B BB[25]:B BB[26]:B BB[27]:B BB[28]:B
*.pininfo BB[29]:B BB[30]:B BB[31]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B
*.pininfo BB[36]:B BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B
*.pininfo BB[43]:B BB[44]:B BB[45]:B BB[46]:B BB[47]:B BB[48]:B BB[49]:B
*.pininfo BB[50]:B BB[51]:B BB[52]:B BB[53]:B BB[54]:B BB[55]:B BB[56]:B
*.pininfo BB[57]:B BB[58]:B BB[59]:B BB[60]:B BB[61]:B BB[62]:B BB[63]:B
*.pininfo BB[64]:B BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B
*.pininfo BB[71]:B BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B
*.pininfo BB[78]:B BB[79]:B BB[80]:B BB[81]:B BB[82]:B BB[83]:B BB[84]:B
*.pininfo BB[85]:B BB[86]:B BB[87]:B BB[88]:B BB[89]:B BB[90]:B BB[91]:B
*.pininfo BB[92]:B BB[93]:B BB[94]:B BB[95]:B BB[96]:B BB[97]:B BB[98]:B
*.pininfo BB[99]:B BB[100]:B BB[101]:B BB[102]:B BB[103]:B BB[104]:B
*.pininfo BB[105]:B BB[106]:B BB[107]:B BB[108]:B BB[109]:B BB[110]:B
*.pininfo BB[111]:B BB[112]:B BB[113]:B BB[114]:B BB[115]:B BB[116]:B
*.pininfo BB[117]:B BB[118]:B BB[119]:B BB[120]:B BB[121]:B BB[122]:B
*.pininfo BB[123]:B BB[124]:B BB[125]:B BB[126]:B BB[127]:B BT[0]:B BT[1]:B
*.pininfo BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B BT[7]:B BT[8]:B BT[9]:B
*.pininfo BT[10]:B BT[11]:B BT[12]:B BT[13]:B BT[14]:B BT[15]:B BT[16]:B
*.pininfo BT[17]:B BT[18]:B BT[19]:B BT[20]:B BT[21]:B BT[22]:B BT[23]:B
*.pininfo BT[24]:B BT[25]:B BT[26]:B BT[27]:B BT[28]:B BT[29]:B BT[30]:B
*.pininfo BT[31]:B BT[32]:B BT[33]:B BT[34]:B BT[35]:B BT[36]:B BT[37]:B
*.pininfo BT[38]:B BT[39]:B BT[40]:B BT[41]:B BT[42]:B BT[43]:B BT[44]:B
*.pininfo BT[45]:B BT[46]:B BT[47]:B BT[48]:B BT[49]:B BT[50]:B BT[51]:B
*.pininfo BT[52]:B BT[53]:B BT[54]:B BT[55]:B BT[56]:B BT[57]:B BT[58]:B
*.pininfo BT[59]:B BT[60]:B BT[61]:B BT[62]:B BT[63]:B BT[64]:B BT[65]:B
*.pininfo BT[66]:B BT[67]:B BT[68]:B BT[69]:B BT[70]:B BT[71]:B BT[72]:B
*.pininfo BT[73]:B BT[74]:B BT[75]:B BT[76]:B BT[77]:B BT[78]:B BT[79]:B
*.pininfo BT[80]:B BT[81]:B BT[82]:B BT[83]:B BT[84]:B BT[85]:B BT[86]:B
*.pininfo BT[87]:B BT[88]:B BT[89]:B BT[90]:B BT[91]:B BT[92]:B BT[93]:B
*.pininfo BT[94]:B BT[95]:B BT[96]:B BT[97]:B BT[98]:B BT[99]:B BT[100]:B
*.pininfo BT[101]:B BT[102]:B BT[103]:B BT[104]:B BT[105]:B BT[106]:B
*.pininfo BT[107]:B BT[108]:B BT[109]:B BT[110]:B BT[111]:B BT[112]:B
*.pininfo BT[113]:B BT[114]:B BT[115]:B BT[116]:B BT[117]:B BT[118]:B
*.pininfo BT[119]:B BT[120]:B BT[121]:B BT[122]:B BT[123]:B BT[124]:B
*.pininfo BT[125]:B BT[126]:B BT[127]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B
*.pininfo GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B
*.pininfo GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B
*.pininfo GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B
*.pininfo GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B
*.pininfo GRD1[31]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B
*.pininfo GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B
*.pininfo GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B
*.pininfo GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B
*.pininfo GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B VSS:B VSSX:B
*.pininfo VDDA:B PD[0]:B PD[1]:B PD[2]:B PD[3]:B RWL:B DBL:B CSH_YS[0]:B
*.pininfo CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B LXWB[0]:B LXWB[1]:B LXWB[2]:B
*.pininfo LXWB[3]:B QT[0]:B QT[1]:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B
*.pininfo QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B RMO[0]:B RMO[1]:B
*.pininfo RMO[2]:B VSB[0]:B VSB[1]:B VSB[2]:B VSB[3]:B WMO[0]:B WMO[1]:B
*.pininfo WMO[2]:B XARLSBA[0]:B XARLSBA[1]:B XARLSBA[2]:B XARLSBA[3]:B
*.pininfo XARMSBA[0]:B XARMSBA[1]:B XARMSBA[2]:B XARMSBA[3]:B XARMSBB[0]:B
*.pininfo XARMSBB[1]:B XARMSBB[2]:B XARMSBB[3]:B CSH_ENB:B BPUI:B SPUI:B
*.pininfo ZRR:B VNW:B DBL0:B LCLKB:B PWR:B ag_ctrl:B CSH_RR:B EN:B ENB:B
*.pininfo T0EN:B CSH_LD:B RWOUT:B BB[128]:B BB[129]:B BB[130]:B BB[131]:B
*.pininfo BB[132]:B BB[133]:B BB[134]:B BB[135]:B BB[136]:B BB[137]:B
*.pininfo BB[138]:B BB[139]:B BB[140]:B BB[141]:B BB[142]:B BB[143]:B
*.pininfo BB[144]:B BB[145]:B BB[146]:B BB[147]:B BB[148]:B BB[149]:B
*.pininfo BB[150]:B BB[151]:B BB[152]:B BB[153]:B BB[154]:B BB[155]:B
*.pininfo BB[156]:B BB[157]:B BB[158]:B BB[159]:B BB[160]:B BB[161]:B
*.pininfo BB[162]:B BB[163]:B BB[164]:B BB[165]:B BB[166]:B BB[167]:B
*.pininfo BB[168]:B BB[169]:B BB[170]:B BB[171]:B BB[172]:B BB[173]:B
*.pininfo BB[174]:B BB[175]:B BB[176]:B BB[177]:B BB[178]:B BB[179]:B
*.pininfo BB[180]:B BB[181]:B BB[182]:B BB[183]:B BB[184]:B BB[185]:B
*.pininfo BB[186]:B BB[187]:B BB[188]:B BB[189]:B BB[190]:B BB[191]:B
*.pininfo BB[192]:B BB[193]:B BB[194]:B BB[195]:B BB[196]:B BB[197]:B
*.pininfo BB[198]:B BB[199]:B BB[200]:B BB[201]:B BB[202]:B BB[203]:B
*.pininfo BB[204]:B BB[205]:B BB[206]:B BB[207]:B BB[208]:B BB[209]:B
*.pininfo BB[210]:B BB[211]:B BB[212]:B BB[213]:B BB[214]:B BB[215]:B
*.pininfo BB[216]:B BB[217]:B BB[218]:B BB[219]:B BB[220]:B BB[221]:B
*.pininfo BB[222]:B BB[223]:B BB[224]:B BB[225]:B BB[226]:B BB[227]:B
*.pininfo BB[228]:B BB[229]:B BB[230]:B BB[231]:B BB[232]:B BB[233]:B
*.pininfo BB[234]:B BB[235]:B BB[236]:B BB[237]:B BB[238]:B BB[239]:B
*.pininfo BB[240]:B BB[241]:B BB[242]:B BB[243]:B BB[244]:B BB[245]:B
*.pininfo BB[246]:B BB[247]:B BB[248]:B BB[249]:B BB[250]:B BB[251]:B
*.pininfo BB[252]:B BB[253]:B BB[254]:B BB[255]:B BT[128]:B BT[129]:B
*.pininfo BT[130]:B BT[131]:B BT[132]:B BT[133]:B BT[134]:B BT[135]:B
*.pininfo BT[136]:B BT[137]:B BT[138]:B BT[139]:B BT[140]:B BT[141]:B
*.pininfo BT[142]:B BT[143]:B BT[144]:B BT[145]:B BT[146]:B BT[147]:B
*.pininfo BT[148]:B BT[149]:B BT[150]:B BT[151]:B BT[152]:B BT[153]:B
*.pininfo BT[154]:B BT[155]:B BT[156]:B BT[157]:B BT[158]:B BT[159]:B
*.pininfo BT[160]:B BT[161]:B BT[162]:B BT[163]:B BT[164]:B BT[165]:B
*.pininfo BT[166]:B BT[167]:B BT[168]:B BT[169]:B BT[170]:B BT[171]:B
*.pininfo BT[172]:B BT[173]:B BT[174]:B BT[175]:B BT[176]:B BT[177]:B
*.pininfo BT[178]:B BT[179]:B BT[180]:B BT[181]:B BT[182]:B BT[183]:B
*.pininfo BT[184]:B BT[185]:B BT[186]:B BT[187]:B BT[188]:B BT[189]:B
*.pininfo BT[190]:B BT[191]:B BT[192]:B BT[193]:B BT[194]:B BT[195]:B
*.pininfo BT[196]:B BT[197]:B BT[198]:B BT[199]:B BT[200]:B BT[201]:B
*.pininfo BT[202]:B BT[203]:B BT[204]:B BT[205]:B BT[206]:B BT[207]:B
*.pininfo BT[208]:B BT[209]:B BT[210]:B BT[211]:B BT[212]:B BT[213]:B
*.pininfo BT[214]:B BT[215]:B BT[216]:B BT[217]:B BT[218]:B BT[219]:B
*.pininfo BT[220]:B BT[221]:B BT[222]:B BT[223]:B BT[224]:B BT[225]:B
*.pininfo BT[226]:B BT[227]:B BT[228]:B BT[229]:B BT[230]:B BT[231]:B
*.pininfo BT[232]:B BT[233]:B BT[234]:B BT[235]:B BT[236]:B BT[237]:B
*.pininfo BT[238]:B BT[239]:B BT[240]:B BT[241]:B BT[242]:B BT[243]:B
*.pininfo BT[244]:B BT[245]:B BT[246]:B BT[247]:B BT[248]:B BT[249]:B
*.pininfo BT[250]:B BT[251]:B BT[252]:B BT[253]:B BT[254]:B BT[255]:B
*.pininfo GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B GBW[13]:B GBW[14]:B
*.pininfo GBW[15]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B GD[12]:B GD[13]:B
*.pininfo GD[14]:B GD[15]:B GRD0[32]:B GRD0[33]:B GRD0[34]:B GRD0[35]:B
*.pininfo GRD0[36]:B GRD0[37]:B GRD0[38]:B GRD0[39]:B GRD0[40]:B GRD0[41]:B
*.pininfo GRD0[42]:B GRD0[43]:B GRD0[44]:B GRD0[45]:B GRD0[46]:B GRD0[47]:B
*.pininfo GRD0[48]:B GRD0[49]:B GRD0[50]:B GRD0[51]:B GRD0[52]:B GRD0[53]:B
*.pininfo GRD0[54]:B GRD0[55]:B GRD0[56]:B GRD0[57]:B GRD0[58]:B GRD0[59]:B
*.pininfo GRD0[60]:B GRD0[61]:B GRD0[62]:B GRD0[63]:B GRD1[32]:B GRD1[33]:B
*.pininfo GRD1[34]:B GRD1[35]:B GRD1[36]:B GRD1[37]:B GRD1[38]:B GRD1[39]:B
*.pininfo GRD1[40]:B GRD1[41]:B GRD1[42]:B GRD1[43]:B GRD1[44]:B GRD1[45]:B
*.pininfo GRD1[46]:B GRD1[47]:B GRD1[48]:B GRD1[49]:B GRD1[50]:B GRD1[51]:B
*.pininfo GRD1[52]:B GRD1[53]:B GRD1[54]:B GRD1[55]:B GRD1[56]:B GRD1[57]:B
*.pininfo GRD1[58]:B GRD1[59]:B GRD1[60]:B GRD1[61]:B GRD1[62]:B GRD1[63]:B
*.pininfo GRD2[32]:B GRD2[33]:B GRD2[34]:B GRD2[35]:B GRD2[36]:B GRD2[37]:B
*.pininfo GRD2[38]:B GRD2[39]:B GRD2[40]:B GRD2[41]:B GRD2[42]:B GRD2[43]:B
*.pininfo GRD2[44]:B GRD2[45]:B GRD2[46]:B GRD2[47]:B GRD2[48]:B GRD2[49]:B
*.pininfo GRD2[50]:B GRD2[51]:B GRD2[52]:B GRD2[53]:B GRD2[54]:B GRD2[55]:B
*.pininfo GRD2[56]:B GRD2[57]:B GRD2[58]:B GRD2[59]:B GRD2[60]:B GRD2[61]:B
*.pininfo GRD2[62]:B GRD2[63]:B GRD3[32]:B GRD3[33]:B GRD3[34]:B GRD3[35]:B
*.pininfo GRD3[36]:B GRD3[37]:B GRD3[38]:B GRD3[39]:B GRD3[40]:B GRD3[41]:B
*.pininfo GRD3[42]:B GRD3[43]:B GRD3[44]:B GRD3[45]:B GRD3[46]:B GRD3[47]:B
*.pininfo GRD3[48]:B GRD3[49]:B GRD3[50]:B GRD3[51]:B GRD3[52]:B GRD3[53]:B
*.pininfo GRD3[54]:B GRD3[55]:B GRD3[56]:B GRD3[57]:B GRD3[58]:B GRD3[59]:B
*.pininfo GRD3[60]:B GRD3[61]:B GRD3[62]:B GRD3[63]:B RBB[0]:B RBB[1]:B
*.pininfo RBB[2]:B RBB[3]:B RBB[4]:B RBB[5]:B RBB[6]:B RBB[7]:B RBB[8]:B
*.pininfo RBB[9]:B RBB[10]:B RBB[11]:B RBB[12]:B RBB[13]:B RBB[14]:B
*.pininfo RBB[15]:B RBT[0]:B RBT[1]:B RBT[2]:B RBT[3]:B RBT[4]:B RBT[5]:B
*.pininfo RBT[6]:B RBT[7]:B RBT[8]:B RBT[9]:B RBT[10]:B RBT[11]:B RBT[12]:B
*.pininfo RBT[13]:B RBT[14]:B RBT[15]:B RGRD0[0]:B RGRD0[1]:B RGRD0[2]:B
*.pininfo RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B RGRD2[0]:B
*.pininfo RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B RGRD3[2]:B
*.pininfo RGRD3[3]:B RGD:B RGBW:B
XXspram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_R_0 BB[0] BB[1] BB[2] BB[3]
+ BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14]
+ BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+ BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34]
+ BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44]
+ BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+ BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64]
+ BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74]
+ BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84]
+ BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94]
+ BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104]
+ BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113]
+ BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122]
+ BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+ BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+ BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+ BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+ BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+ BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+ BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66]
+ BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76]
+ BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86]
+ BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96]
+ BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+ BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113] BT[114]
+ BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+ BT[124] BT[125] BT[126] BT[127] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5]
+ GBW[6] GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0]
+ GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9]
+ GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17]
+ GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25]
+ GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10]
+ GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26]
+ GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2]
+ GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19]
+ GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27]
+ GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4]
+ GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13]
+ GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21]
+ GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] VSS VSSX VDDA RWL DBL PD[0] PD[1] PD[2] PD[3] WLC[0]
+ WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6] WLC[7] WLC[8] WLC[9] WLC[10]
+ WLC[11] WLC[12] WLC[13] WLC[14] WLC[15] WLC[16] WLC[17] WLC[18] WLC[19]
+ WLC[20] WLC[21] WLC[22] WLC[23] WLC[24] WLC[25] WLC[26] WLC[27] WLC[28]
+ WLC[29] WLC[30] WLC[31] WLC[32] WLC[33] WLC[34] WLC[35] WLC[36] WLC[37]
+ WLC[38] WLC[39] WLC[40] WLC[41] WLC[42] WLC[43] WLC[44] WLC[45] WLC[46]
+ WLC[47] WLC[48] WLC[49] WLC[50] WLC[51] WLC[52] WLC[53] WLC[54] WLC[55]
+ WLC[56] WLC[57] WLC[58] WLC[59] WLC[60] WLC[61] WLC[62] WLC[63] WLC[64]
+ WLC[65] WLC[66] WLC[67] WLC[68] WLC[69] WLC[70] WLC[71] WLC[72] WLC[73]
+ WLC[74] WLC[75] WLC[76] WLC[77] WLC[78] WLC[79] WLC[80] WLC[81] WLC[82]
+ WLC[83] WLC[84] WLC[85] WLC[86] WLC[87] WLC[88] WLC[89] WLC[90] WLC[91]
+ WLC[92] WLC[93] WLC[94] WLC[95] WLC[96] WLC[97] WLC[98] WLC[99] WLC[100]
+ WLC[101] WLC[102] WLC[103] WLC[104] WLC[105] WLC[106] WLC[107] WLC[108]
+ WLC[109] WLC[110] WLC[111] WLC[112] WLC[113] WLC[114] WLC[115] WLC[116]
+ WLC[117] WLC[118] WLC[119] WLC[120] WLC[121] WLC[122] WLC[123] WLC[124]
+ WLC[125] WLC[126] WLC[127] WLC[128] WLC[129] WLC[130] WLC[131] WLC[132]
+ WLC[133] WLC[134] WLC[135] WLC[136] WLC[137] WLC[138] WLC[139] WLC[140]
+ WLC[141] WLC[142] WLC[143] WLC[144] WLC[145] WLC[146] WLC[147] WLC[148]
+ WLC[149] WLC[150] WLC[151] WLC[152] WLC[153] WLC[154] WLC[155] WLC[156]
+ WLC[157] WLC[158] WLC[159] WLC[160] WLC[161] WLC[162] WLC[163] WLC[164]
+ WLC[165] WLC[166] WLC[167] WLC[168] WLC[169] WLC[170] WLC[171] WLC[172]
+ WLC[173] WLC[174] WLC[175] WLC[176] WLC[177] WLC[178] WLC[179] WLC[180]
+ WLC[181] WLC[182] WLC[183] WLC[184] WLC[185] WLC[186] WLC[187] WLC[188]
+ WLC[189] WLC[190] WLC[191] WLC[192] WLC[193] WLC[194] WLC[195] WLC[196]
+ WLC[197] WLC[198] WLC[199] WLC[200] WLC[201] WLC[202] WLC[203] WLC[204]
+ WLC[205] WLC[206] WLC[207] WLC[208] WLC[209] WLC[210] WLC[211] WLC[212]
+ WLC[213] WLC[214] WLC[215] WLC[216] WLC[217] WLC[218] WLC[219] WLC[220]
+ WLC[221] WLC[222] WLC[223] WLC[224] WLC[225] WLC[226] WLC[227] WLC[228]
+ WLC[229] WLC[230] WLC[231] WLC[232] WLC[233] WLC[234] WLC[235] WLC[236]
+ WLC[237] WLC[238] WLC[239] WLC[240] WLC[241] WLC[242] WLC[243] WLC[244]
+ WLC[245] WLC[246] WLC[247] WLC[248] WLC[249] WLC[250] WLC[251] WLC[252]
+ WLC[253] WLC[254] WLC[255] VNW PWR
+ spram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_R m=1
XXspram_4096x16m16b1pm2re1RE1M16_B1SBNK_XDEC_0 CSH_YS[0] CSH_YS[1] CSH_YS[2]
+ CSH_YS[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] QT[0] QT[1] QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] RMO[0] RMO[1] RMO[2] VSB[0]
+ VSB[1] VSB[2] VSB[3] WMO[0] WMO[1] WMO[2] XARLSBA[0] XARLSBA[1] XARLSBA[2]
+ XARLSBA[3] XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0]
+ XARMSBB[1] XARMSBB[2] XARMSBB[3] CSH_ENB BPUI SPUI ZRR VNW DBL0 LCLKB PWR
+ ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT VSSX PD[0] PD[1] PD[2] PD[3] WLC[0]
+ WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6] WLC[7] WLC[8] WLC[9] WLC[10]
+ WLC[11] WLC[12] WLC[13] WLC[14] WLC[15] WLC[16] WLC[17] WLC[18] WLC[19]
+ WLC[20] WLC[21] WLC[22] WLC[23] WLC[24] WLC[25] WLC[26] WLC[27] WLC[28]
+ WLC[29] WLC[30] WLC[31] WLC[32] WLC[33] WLC[34] WLC[35] WLC[36] WLC[37]
+ WLC[38] WLC[39] WLC[40] WLC[41] WLC[42] WLC[43] WLC[44] WLC[45] WLC[46]
+ WLC[47] WLC[48] WLC[49] WLC[50] WLC[51] WLC[52] WLC[53] WLC[54] WLC[55]
+ WLC[56] WLC[57] WLC[58] WLC[59] WLC[60] WLC[61] WLC[62] WLC[63] WLC[64]
+ WLC[65] WLC[66] WLC[67] WLC[68] WLC[69] WLC[70] WLC[71] WLC[72] WLC[73]
+ WLC[74] WLC[75] WLC[76] WLC[77] WLC[78] WLC[79] WLC[80] WLC[81] WLC[82]
+ WLC[83] WLC[84] WLC[85] WLC[86] WLC[87] WLC[88] WLC[89] WLC[90] WLC[91]
+ WLC[92] WLC[93] WLC[94] WLC[95] WLC[96] WLC[97] WLC[98] WLC[99] WLC[100]
+ WLC[101] WLC[102] WLC[103] WLC[104] WLC[105] WLC[106] WLC[107] WLC[108]
+ WLC[109] WLC[110] WLC[111] WLC[112] WLC[113] WLC[114] WLC[115] WLC[116]
+ WLC[117] WLC[118] WLC[119] WLC[120] WLC[121] WLC[122] WLC[123] WLC[124]
+ WLC[125] WLC[126] WLC[127] WLC[128] WLC[129] WLC[130] WLC[131] WLC[132]
+ WLC[133] WLC[134] WLC[135] WLC[136] WLC[137] WLC[138] WLC[139] WLC[140]
+ WLC[141] WLC[142] WLC[143] WLC[144] WLC[145] WLC[146] WLC[147] WLC[148]
+ WLC[149] WLC[150] WLC[151] WLC[152] WLC[153] WLC[154] WLC[155] WLC[156]
+ WLC[157] WLC[158] WLC[159] WLC[160] WLC[161] WLC[162] WLC[163] WLC[164]
+ WLC[165] WLC[166] WLC[167] WLC[168] WLC[169] WLC[170] WLC[171] WLC[172]
+ WLC[173] WLC[174] WLC[175] WLC[176] WLC[177] WLC[178] WLC[179] WLC[180]
+ WLC[181] WLC[182] WLC[183] WLC[184] WLC[185] WLC[186] WLC[187] WLC[188]
+ WLC[189] WLC[190] WLC[191] WLC[192] WLC[193] WLC[194] WLC[195] WLC[196]
+ WLC[197] WLC[198] WLC[199] WLC[200] WLC[201] WLC[202] WLC[203] WLC[204]
+ WLC[205] WLC[206] WLC[207] WLC[208] WLC[209] WLC[210] WLC[211] WLC[212]
+ WLC[213] WLC[214] WLC[215] WLC[216] WLC[217] WLC[218] WLC[219] WLC[220]
+ WLC[221] WLC[222] WLC[223] WLC[224] WLC[225] WLC[226] WLC[227] WLC[228]
+ WLC[229] WLC[230] WLC[231] WLC[232] WLC[233] WLC[234] WLC[235] WLC[236]
+ WLC[237] WLC[238] WLC[239] WLC[240] WLC[241] WLC[242] WLC[243] WLC[244]
+ WLC[245] WLC[246] WLC[247] WLC[248] WLC[249] WLC[250] WLC[251] WLC[252]
+ WLC[253] WLC[254] WLC[255] VDDA VSS RWL DBL
+ spram_4096x16m16b1pm2re1RE1M16_B1SBNK_XDEC m=1
XXspram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_L_0 BB[128] BB[129] BB[130]
+ BB[131] BB[132] BB[133] BB[134] BB[135] BB[136] BB[137] BB[138] BB[139]
+ BB[140] BB[141] BB[142] BB[143] BB[144] BB[145] BB[146] BB[147] BB[148]
+ BB[149] BB[150] BB[151] BB[152] BB[153] BB[154] BB[155] BB[156] BB[157]
+ BB[158] BB[159] BB[160] BB[161] BB[162] BB[163] BB[164] BB[165] BB[166]
+ BB[167] BB[168] BB[169] BB[170] BB[171] BB[172] BB[173] BB[174] BB[175]
+ BB[176] BB[177] BB[178] BB[179] BB[180] BB[181] BB[182] BB[183] BB[184]
+ BB[185] BB[186] BB[187] BB[188] BB[189] BB[190] BB[191] BB[192] BB[193]
+ BB[194] BB[195] BB[196] BB[197] BB[198] BB[199] BB[200] BB[201] BB[202]
+ BB[203] BB[204] BB[205] BB[206] BB[207] BB[208] BB[209] BB[210] BB[211]
+ BB[212] BB[213] BB[214] BB[215] BB[216] BB[217] BB[218] BB[219] BB[220]
+ BB[221] BB[222] BB[223] BB[224] BB[225] BB[226] BB[227] BB[228] BB[229]
+ BB[230] BB[231] BB[232] BB[233] BB[234] BB[235] BB[236] BB[237] BB[238]
+ BB[239] BB[240] BB[241] BB[242] BB[243] BB[244] BB[245] BB[246] BB[247]
+ BB[248] BB[249] BB[250] BB[251] BB[252] BB[253] BB[254] BB[255] BT[128]
+ BT[129] BT[130] BT[131] BT[132] BT[133] BT[134] BT[135] BT[136] BT[137]
+ BT[138] BT[139] BT[140] BT[141] BT[142] BT[143] BT[144] BT[145] BT[146]
+ BT[147] BT[148] BT[149] BT[150] BT[151] BT[152] BT[153] BT[154] BT[155]
+ BT[156] BT[157] BT[158] BT[159] BT[160] BT[161] BT[162] BT[163] BT[164]
+ BT[165] BT[166] BT[167] BT[168] BT[169] BT[170] BT[171] BT[172] BT[173]
+ BT[174] BT[175] BT[176] BT[177] BT[178] BT[179] BT[180] BT[181] BT[182]
+ BT[183] BT[184] BT[185] BT[186] BT[187] BT[188] BT[189] BT[190] BT[191]
+ BT[192] BT[193] BT[194] BT[195] BT[196] BT[197] BT[198] BT[199] BT[200]
+ BT[201] BT[202] BT[203] BT[204] BT[205] BT[206] BT[207] BT[208] BT[209]
+ BT[210] BT[211] BT[212] BT[213] BT[214] BT[215] BT[216] BT[217] BT[218]
+ BT[219] BT[220] BT[221] BT[222] BT[223] BT[224] BT[225] BT[226] BT[227]
+ BT[228] BT[229] BT[230] BT[231] BT[232] BT[233] BT[234] BT[235] BT[236]
+ BT[237] BT[238] BT[239] BT[240] BT[241] BT[242] BT[243] BT[244] BT[245]
+ BT[246] BT[247] BT[248] BT[249] BT[250] BT[251] BT[252] BT[253] BT[254]
+ BT[255] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8]
+ GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34]
+ GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42]
+ GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50]
+ GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58]
+ GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34]
+ GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42]
+ GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50]
+ GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58]
+ GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34]
+ GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42]
+ GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50]
+ GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58]
+ GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] RBB[0] RBB[1] RBB[2] RBB[3]
+ RBB[4] RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13]
+ RBB[14] RBB[15] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4] RBT[5] RBT[6] RBT[7]
+ RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14] RBT[15] RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0]
+ RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] VSS VSSX
+ VDDA RGD RGBW WLC[0] WLC[1] WLC[2] WLC[3] WLC[4] WLC[5] WLC[6] WLC[7]
+ WLC[8] WLC[9] WLC[10] WLC[11] WLC[12] WLC[13] WLC[14] WLC[15] WLC[16]
+ WLC[17] WLC[18] WLC[19] WLC[20] WLC[21] WLC[22] WLC[23] WLC[24] WLC[25]
+ WLC[26] WLC[27] WLC[28] WLC[29] WLC[30] WLC[31] WLC[32] WLC[33] WLC[34]
+ WLC[35] WLC[36] WLC[37] WLC[38] WLC[39] WLC[40] WLC[41] WLC[42] WLC[43]
+ WLC[44] WLC[45] WLC[46] WLC[47] WLC[48] WLC[49] WLC[50] WLC[51] WLC[52]
+ WLC[53] WLC[54] WLC[55] WLC[56] WLC[57] WLC[58] WLC[59] WLC[60] WLC[61]
+ WLC[62] WLC[63] WLC[64] WLC[65] WLC[66] WLC[67] WLC[68] WLC[69] WLC[70]
+ WLC[71] WLC[72] WLC[73] WLC[74] WLC[75] WLC[76] WLC[77] WLC[78] WLC[79]
+ WLC[80] WLC[81] WLC[82] WLC[83] WLC[84] WLC[85] WLC[86] WLC[87] WLC[88]
+ WLC[89] WLC[90] WLC[91] WLC[92] WLC[93] WLC[94] WLC[95] WLC[96] WLC[97]
+ WLC[98] WLC[99] WLC[100] WLC[101] WLC[102] WLC[103] WLC[104] WLC[105]
+ WLC[106] WLC[107] WLC[108] WLC[109] WLC[110] WLC[111] WLC[112] WLC[113]
+ WLC[114] WLC[115] WLC[116] WLC[117] WLC[118] WLC[119] WLC[120] WLC[121]
+ WLC[122] WLC[123] WLC[124] WLC[125] WLC[126] WLC[127] WLC[128] WLC[129]
+ WLC[130] WLC[131] WLC[132] WLC[133] WLC[134] WLC[135] WLC[136] WLC[137]
+ WLC[138] WLC[139] WLC[140] WLC[141] WLC[142] WLC[143] WLC[144] WLC[145]
+ WLC[146] WLC[147] WLC[148] WLC[149] WLC[150] WLC[151] WLC[152] WLC[153]
+ WLC[154] WLC[155] WLC[156] WLC[157] WLC[158] WLC[159] WLC[160] WLC[161]
+ WLC[162] WLC[163] WLC[164] WLC[165] WLC[166] WLC[167] WLC[168] WLC[169]
+ WLC[170] WLC[171] WLC[172] WLC[173] WLC[174] WLC[175] WLC[176] WLC[177]
+ WLC[178] WLC[179] WLC[180] WLC[181] WLC[182] WLC[183] WLC[184] WLC[185]
+ WLC[186] WLC[187] WLC[188] WLC[189] WLC[190] WLC[191] WLC[192] WLC[193]
+ WLC[194] WLC[195] WLC[196] WLC[197] WLC[198] WLC[199] WLC[200] WLC[201]
+ WLC[202] WLC[203] WLC[204] WLC[205] WLC[206] WLC[207] WLC[208] WLC[209]
+ WLC[210] WLC[211] WLC[212] WLC[213] WLC[214] WLC[215] WLC[216] WLC[217]
+ WLC[218] WLC[219] WLC[220] WLC[221] WLC[222] WLC[223] WLC[224] WLC[225]
+ WLC[226] WLC[227] WLC[228] WLC[229] WLC[230] WLC[231] WLC[232] WLC[233]
+ WLC[234] WLC[235] WLC[236] WLC[237] WLC[238] WLC[239] WLC[240] WLC[241]
+ WLC[242] WLC[243] WLC[244] WLC[245] WLC[246] WLC[247] WLC[248] WLC[249]
+ WLC[250] WLC[251] WLC[252] WLC[253] WLC[254] WLC[255] VNW PWR
+ spram_4096x16m16b1pm2re1RE1M16_B1SBNK_BITARY_L m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1SBNK

.subckt spram_4096x16m16b1pm2re1RE1M16_B1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+ BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+ BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+ BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+ BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+ BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+ BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+ BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+ BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+ BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+ BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+ BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+ BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+ BB[124] BB[125] BB[126] BB[127] BB[128] BB[129] BB[130] BB[131] BB[132]
+ BB[133] BB[134] BB[135] BB[136] BB[137] BB[138] BB[139] BB[140] BB[141]
+ BB[142] BB[143] BB[144] BB[145] BB[146] BB[147] BB[148] BB[149] BB[150]
+ BB[151] BB[152] BB[153] BB[154] BB[155] BB[156] BB[157] BB[158] BB[159]
+ BB[160] BB[161] BB[162] BB[163] BB[164] BB[165] BB[166] BB[167] BB[168]
+ BB[169] BB[170] BB[171] BB[172] BB[173] BB[174] BB[175] BB[176] BB[177]
+ BB[178] BB[179] BB[180] BB[181] BB[182] BB[183] BB[184] BB[185] BB[186]
+ BB[187] BB[188] BB[189] BB[190] BB[191] BB[192] BB[193] BB[194] BB[195]
+ BB[196] BB[197] BB[198] BB[199] BB[200] BB[201] BB[202] BB[203] BB[204]
+ BB[205] BB[206] BB[207] BB[208] BB[209] BB[210] BB[211] BB[212] BB[213]
+ BB[214] BB[215] BB[216] BB[217] BB[218] BB[219] BB[220] BB[221] BB[222]
+ BB[223] BB[224] BB[225] BB[226] BB[227] BB[228] BB[229] BB[230] BB[231]
+ BB[232] BB[233] BB[234] BB[235] BB[236] BB[237] BB[238] BB[239] BB[240]
+ BB[241] BB[242] BB[243] BB[244] BB[245] BB[246] BB[247] BB[248] BB[249]
+ BB[250] BB[251] BB[252] BB[253] BB[254] BB[255] BT[0] BT[1] BT[2] BT[3]
+ BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+ BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+ BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+ BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+ BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+ BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+ BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74]
+ BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+ BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+ BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104]
+ BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113]
+ BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122]
+ BT[123] BT[124] BT[125] BT[126] BT[127] BT[128] BT[129] BT[130] BT[131]
+ BT[132] BT[133] BT[134] BT[135] BT[136] BT[137] BT[138] BT[139] BT[140]
+ BT[141] BT[142] BT[143] BT[144] BT[145] BT[146] BT[147] BT[148] BT[149]
+ BT[150] BT[151] BT[152] BT[153] BT[154] BT[155] BT[156] BT[157] BT[158]
+ BT[159] BT[160] BT[161] BT[162] BT[163] BT[164] BT[165] BT[166] BT[167]
+ BT[168] BT[169] BT[170] BT[171] BT[172] BT[173] BT[174] BT[175] BT[176]
+ BT[177] BT[178] BT[179] BT[180] BT[181] BT[182] BT[183] BT[184] BT[185]
+ BT[186] BT[187] BT[188] BT[189] BT[190] BT[191] BT[192] BT[193] BT[194]
+ BT[195] BT[196] BT[197] BT[198] BT[199] BT[200] BT[201] BT[202] BT[203]
+ BT[204] BT[205] BT[206] BT[207] BT[208] BT[209] BT[210] BT[211] BT[212]
+ BT[213] BT[214] BT[215] BT[216] BT[217] BT[218] BT[219] BT[220] BT[221]
+ BT[222] BT[223] BT[224] BT[225] BT[226] BT[227] BT[228] BT[229] BT[230]
+ BT[231] BT[232] BT[233] BT[234] BT[235] BT[236] BT[237] BT[238] BT[239]
+ BT[240] BT[241] BT[242] BT[243] BT[244] BT[245] BT[246] BT[247] BT[248]
+ BT[249] BT[250] BT[251] BT[252] BT[253] BT[254] BT[255] CSH_YS[0] CSH_YS[1]
+ CSH_YS[2] CSH_YS[3] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7]
+ GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[0] GD[1]
+ GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13]
+ GD[14] GD[15] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6]
+ GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14]
+ GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22]
+ GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30]
+ GRD0[31] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37] GRD0[38]
+ GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45] GRD0[46]
+ GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53] GRD0[54]
+ GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61] GRD0[62]
+ GRD0[63] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7]
+ GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15]
+ GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23]
+ GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31]
+ GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39]
+ GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47]
+ GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55]
+ GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63]
+ GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8]
+ GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16]
+ GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24]
+ GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD2[32]
+ GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40]
+ GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48]
+ GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56]
+ GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[0]
+ GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9]
+ GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16] GRD3[17]
+ GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24] GRD3[25]
+ GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] GRD3[32] GRD3[33]
+ GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41]
+ GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49]
+ GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57]
+ GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] LXWB[0] LXWB[1]
+ LXWB[2] LXWB[3] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+ QT[10] QT[11] RBB[0] RBB[1] RBB[2] RBB[3] RBB[4] RBB[5] RBB[6] RBB[7]
+ RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13] RBB[14] RBB[15] RBT[0] RBT[1]
+ RBT[2] RBT[3] RBT[4] RBT[5] RBT[6] RBT[7] RBT[8] RBT[9] RBT[10] RBT[11]
+ RBT[12] RBT[13] RBT[14] RBT[15] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3]
+ RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3]
+ RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RMO[0] RMO[1] RMO[2] VSB[0] VSB[1]
+ VSB[2] VSB[3] WMO[0] WMO[1] WMO[2] XARLSBA[0] XARLSBA[1] XARLSBA[2]
+ XARLSBA[3] XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3] XARMSBB[0]
+ XARMSBB[1] XARMSBB[2] XARMSBB[3] VSS VSSX VDDA CSH_ENB BPUI SPUI ZRR VNW
+ DBL0 LCLKB PWR ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT RGD RGBW PD[0] PD[1]
+ PD[2] PD[3] RWL DBL
*.pininfo BB[0]:B BB[1]:B BB[2]:B BB[3]:B BB[4]:B BB[5]:B BB[6]:B BB[7]:B
*.pininfo BB[8]:B BB[9]:B BB[10]:B BB[11]:B BB[12]:B BB[13]:B BB[14]:B
*.pininfo BB[15]:B BB[16]:B BB[17]:B BB[18]:B BB[19]:B BB[20]:B BB[21]:B
*.pininfo BB[22]:B BB[23]:B BB[24]:B BB[25]:B BB[26]:B BB[27]:B BB[28]:B
*.pininfo BB[29]:B BB[30]:B BB[31]:B BB[32]:B BB[33]:B BB[34]:B BB[35]:B
*.pininfo BB[36]:B BB[37]:B BB[38]:B BB[39]:B BB[40]:B BB[41]:B BB[42]:B
*.pininfo BB[43]:B BB[44]:B BB[45]:B BB[46]:B BB[47]:B BB[48]:B BB[49]:B
*.pininfo BB[50]:B BB[51]:B BB[52]:B BB[53]:B BB[54]:B BB[55]:B BB[56]:B
*.pininfo BB[57]:B BB[58]:B BB[59]:B BB[60]:B BB[61]:B BB[62]:B BB[63]:B
*.pininfo BB[64]:B BB[65]:B BB[66]:B BB[67]:B BB[68]:B BB[69]:B BB[70]:B
*.pininfo BB[71]:B BB[72]:B BB[73]:B BB[74]:B BB[75]:B BB[76]:B BB[77]:B
*.pininfo BB[78]:B BB[79]:B BB[80]:B BB[81]:B BB[82]:B BB[83]:B BB[84]:B
*.pininfo BB[85]:B BB[86]:B BB[87]:B BB[88]:B BB[89]:B BB[90]:B BB[91]:B
*.pininfo BB[92]:B BB[93]:B BB[94]:B BB[95]:B BB[96]:B BB[97]:B BB[98]:B
*.pininfo BB[99]:B BB[100]:B BB[101]:B BB[102]:B BB[103]:B BB[104]:B
*.pininfo BB[105]:B BB[106]:B BB[107]:B BB[108]:B BB[109]:B BB[110]:B
*.pininfo BB[111]:B BB[112]:B BB[113]:B BB[114]:B BB[115]:B BB[116]:B
*.pininfo BB[117]:B BB[118]:B BB[119]:B BB[120]:B BB[121]:B BB[122]:B
*.pininfo BB[123]:B BB[124]:B BB[125]:B BB[126]:B BB[127]:B BB[128]:B
*.pininfo BB[129]:B BB[130]:B BB[131]:B BB[132]:B BB[133]:B BB[134]:B
*.pininfo BB[135]:B BB[136]:B BB[137]:B BB[138]:B BB[139]:B BB[140]:B
*.pininfo BB[141]:B BB[142]:B BB[143]:B BB[144]:B BB[145]:B BB[146]:B
*.pininfo BB[147]:B BB[148]:B BB[149]:B BB[150]:B BB[151]:B BB[152]:B
*.pininfo BB[153]:B BB[154]:B BB[155]:B BB[156]:B BB[157]:B BB[158]:B
*.pininfo BB[159]:B BB[160]:B BB[161]:B BB[162]:B BB[163]:B BB[164]:B
*.pininfo BB[165]:B BB[166]:B BB[167]:B BB[168]:B BB[169]:B BB[170]:B
*.pininfo BB[171]:B BB[172]:B BB[173]:B BB[174]:B BB[175]:B BB[176]:B
*.pininfo BB[177]:B BB[178]:B BB[179]:B BB[180]:B BB[181]:B BB[182]:B
*.pininfo BB[183]:B BB[184]:B BB[185]:B BB[186]:B BB[187]:B BB[188]:B
*.pininfo BB[189]:B BB[190]:B BB[191]:B BB[192]:B BB[193]:B BB[194]:B
*.pininfo BB[195]:B BB[196]:B BB[197]:B BB[198]:B BB[199]:B BB[200]:B
*.pininfo BB[201]:B BB[202]:B BB[203]:B BB[204]:B BB[205]:B BB[206]:B
*.pininfo BB[207]:B BB[208]:B BB[209]:B BB[210]:B BB[211]:B BB[212]:B
*.pininfo BB[213]:B BB[214]:B BB[215]:B BB[216]:B BB[217]:B BB[218]:B
*.pininfo BB[219]:B BB[220]:B BB[221]:B BB[222]:B BB[223]:B BB[224]:B
*.pininfo BB[225]:B BB[226]:B BB[227]:B BB[228]:B BB[229]:B BB[230]:B
*.pininfo BB[231]:B BB[232]:B BB[233]:B BB[234]:B BB[235]:B BB[236]:B
*.pininfo BB[237]:B BB[238]:B BB[239]:B BB[240]:B BB[241]:B BB[242]:B
*.pininfo BB[243]:B BB[244]:B BB[245]:B BB[246]:B BB[247]:B BB[248]:B
*.pininfo BB[249]:B BB[250]:B BB[251]:B BB[252]:B BB[253]:B BB[254]:B
*.pininfo BB[255]:B BT[0]:B BT[1]:B BT[2]:B BT[3]:B BT[4]:B BT[5]:B BT[6]:B
*.pininfo BT[7]:B BT[8]:B BT[9]:B BT[10]:B BT[11]:B BT[12]:B BT[13]:B
*.pininfo BT[14]:B BT[15]:B BT[16]:B BT[17]:B BT[18]:B BT[19]:B BT[20]:B
*.pininfo BT[21]:B BT[22]:B BT[23]:B BT[24]:B BT[25]:B BT[26]:B BT[27]:B
*.pininfo BT[28]:B BT[29]:B BT[30]:B BT[31]:B BT[32]:B BT[33]:B BT[34]:B
*.pininfo BT[35]:B BT[36]:B BT[37]:B BT[38]:B BT[39]:B BT[40]:B BT[41]:B
*.pininfo BT[42]:B BT[43]:B BT[44]:B BT[45]:B BT[46]:B BT[47]:B BT[48]:B
*.pininfo BT[49]:B BT[50]:B BT[51]:B BT[52]:B BT[53]:B BT[54]:B BT[55]:B
*.pininfo BT[56]:B BT[57]:B BT[58]:B BT[59]:B BT[60]:B BT[61]:B BT[62]:B
*.pininfo BT[63]:B BT[64]:B BT[65]:B BT[66]:B BT[67]:B BT[68]:B BT[69]:B
*.pininfo BT[70]:B BT[71]:B BT[72]:B BT[73]:B BT[74]:B BT[75]:B BT[76]:B
*.pininfo BT[77]:B BT[78]:B BT[79]:B BT[80]:B BT[81]:B BT[82]:B BT[83]:B
*.pininfo BT[84]:B BT[85]:B BT[86]:B BT[87]:B BT[88]:B BT[89]:B BT[90]:B
*.pininfo BT[91]:B BT[92]:B BT[93]:B BT[94]:B BT[95]:B BT[96]:B BT[97]:B
*.pininfo BT[98]:B BT[99]:B BT[100]:B BT[101]:B BT[102]:B BT[103]:B BT[104]:B
*.pininfo BT[105]:B BT[106]:B BT[107]:B BT[108]:B BT[109]:B BT[110]:B
*.pininfo BT[111]:B BT[112]:B BT[113]:B BT[114]:B BT[115]:B BT[116]:B
*.pininfo BT[117]:B BT[118]:B BT[119]:B BT[120]:B BT[121]:B BT[122]:B
*.pininfo BT[123]:B BT[124]:B BT[125]:B BT[126]:B BT[127]:B BT[128]:B
*.pininfo BT[129]:B BT[130]:B BT[131]:B BT[132]:B BT[133]:B BT[134]:B
*.pininfo BT[135]:B BT[136]:B BT[137]:B BT[138]:B BT[139]:B BT[140]:B
*.pininfo BT[141]:B BT[142]:B BT[143]:B BT[144]:B BT[145]:B BT[146]:B
*.pininfo BT[147]:B BT[148]:B BT[149]:B BT[150]:B BT[151]:B BT[152]:B
*.pininfo BT[153]:B BT[154]:B BT[155]:B BT[156]:B BT[157]:B BT[158]:B
*.pininfo BT[159]:B BT[160]:B BT[161]:B BT[162]:B BT[163]:B BT[164]:B
*.pininfo BT[165]:B BT[166]:B BT[167]:B BT[168]:B BT[169]:B BT[170]:B
*.pininfo BT[171]:B BT[172]:B BT[173]:B BT[174]:B BT[175]:B BT[176]:B
*.pininfo BT[177]:B BT[178]:B BT[179]:B BT[180]:B BT[181]:B BT[182]:B
*.pininfo BT[183]:B BT[184]:B BT[185]:B BT[186]:B BT[187]:B BT[188]:B
*.pininfo BT[189]:B BT[190]:B BT[191]:B BT[192]:B BT[193]:B BT[194]:B
*.pininfo BT[195]:B BT[196]:B BT[197]:B BT[198]:B BT[199]:B BT[200]:B
*.pininfo BT[201]:B BT[202]:B BT[203]:B BT[204]:B BT[205]:B BT[206]:B
*.pininfo BT[207]:B BT[208]:B BT[209]:B BT[210]:B BT[211]:B BT[212]:B
*.pininfo BT[213]:B BT[214]:B BT[215]:B BT[216]:B BT[217]:B BT[218]:B
*.pininfo BT[219]:B BT[220]:B BT[221]:B BT[222]:B BT[223]:B BT[224]:B
*.pininfo BT[225]:B BT[226]:B BT[227]:B BT[228]:B BT[229]:B BT[230]:B
*.pininfo BT[231]:B BT[232]:B BT[233]:B BT[234]:B BT[235]:B BT[236]:B
*.pininfo BT[237]:B BT[238]:B BT[239]:B BT[240]:B BT[241]:B BT[242]:B
*.pininfo BT[243]:B BT[244]:B BT[245]:B BT[246]:B BT[247]:B BT[248]:B
*.pininfo BT[249]:B BT[250]:B BT[251]:B BT[252]:B BT[253]:B BT[254]:B
*.pininfo BT[255]:B CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B CSH_YS[3]:B GBW[0]:B
*.pininfo GBW[1]:B GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B
*.pininfo GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B GBW[13]:B GBW[14]:B
*.pininfo GBW[15]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B
*.pininfo GD[7]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B GD[12]:B GD[13]:B
*.pininfo GD[14]:B GD[15]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B
*.pininfo GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B
*.pininfo GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B
*.pininfo GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B
*.pininfo GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B
*.pininfo GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD0[32]:B GRD0[33]:B GRD0[34]:B
*.pininfo GRD0[35]:B GRD0[36]:B GRD0[37]:B GRD0[38]:B GRD0[39]:B GRD0[40]:B
*.pininfo GRD0[41]:B GRD0[42]:B GRD0[43]:B GRD0[44]:B GRD0[45]:B GRD0[46]:B
*.pininfo GRD0[47]:B GRD0[48]:B GRD0[49]:B GRD0[50]:B GRD0[51]:B GRD0[52]:B
*.pininfo GRD0[53]:B GRD0[54]:B GRD0[55]:B GRD0[56]:B GRD0[57]:B GRD0[58]:B
*.pininfo GRD0[59]:B GRD0[60]:B GRD0[61]:B GRD0[62]:B GRD0[63]:B GRD1[0]:B
*.pininfo GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B
*.pininfo GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B
*.pininfo GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B
*.pininfo GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B
*.pininfo GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B
*.pininfo GRD1[31]:B GRD1[32]:B GRD1[33]:B GRD1[34]:B GRD1[35]:B GRD1[36]:B
*.pininfo GRD1[37]:B GRD1[38]:B GRD1[39]:B GRD1[40]:B GRD1[41]:B GRD1[42]:B
*.pininfo GRD1[43]:B GRD1[44]:B GRD1[45]:B GRD1[46]:B GRD1[47]:B GRD1[48]:B
*.pininfo GRD1[49]:B GRD1[50]:B GRD1[51]:B GRD1[52]:B GRD1[53]:B GRD1[54]:B
*.pininfo GRD1[55]:B GRD1[56]:B GRD1[57]:B GRD1[58]:B GRD1[59]:B GRD1[60]:B
*.pininfo GRD1[61]:B GRD1[62]:B GRD1[63]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B
*.pininfo GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B
*.pininfo GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B
*.pininfo GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B
*.pininfo GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B
*.pininfo GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD2[32]:B
*.pininfo GRD2[33]:B GRD2[34]:B GRD2[35]:B GRD2[36]:B GRD2[37]:B GRD2[38]:B
*.pininfo GRD2[39]:B GRD2[40]:B GRD2[41]:B GRD2[42]:B GRD2[43]:B GRD2[44]:B
*.pininfo GRD2[45]:B GRD2[46]:B GRD2[47]:B GRD2[48]:B GRD2[49]:B GRD2[50]:B
*.pininfo GRD2[51]:B GRD2[52]:B GRD2[53]:B GRD2[54]:B GRD2[55]:B GRD2[56]:B
*.pininfo GRD2[57]:B GRD2[58]:B GRD2[59]:B GRD2[60]:B GRD2[61]:B GRD2[62]:B
*.pininfo GRD2[63]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B
*.pininfo GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B
*.pininfo GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B
*.pininfo GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B
*.pininfo GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B
*.pininfo GRD3[29]:B GRD3[30]:B GRD3[31]:B GRD3[32]:B GRD3[33]:B GRD3[34]:B
*.pininfo GRD3[35]:B GRD3[36]:B GRD3[37]:B GRD3[38]:B GRD3[39]:B GRD3[40]:B
*.pininfo GRD3[41]:B GRD3[42]:B GRD3[43]:B GRD3[44]:B GRD3[45]:B GRD3[46]:B
*.pininfo GRD3[47]:B GRD3[48]:B GRD3[49]:B GRD3[50]:B GRD3[51]:B GRD3[52]:B
*.pininfo GRD3[53]:B GRD3[54]:B GRD3[55]:B GRD3[56]:B GRD3[57]:B GRD3[58]:B
*.pininfo GRD3[59]:B GRD3[60]:B GRD3[61]:B GRD3[62]:B GRD3[63]:B LXWB[0]:B
*.pininfo LXWB[1]:B LXWB[2]:B LXWB[3]:B QT[0]:B QT[1]:B QT[2]:B QT[3]:B
*.pininfo QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B
*.pininfo RBB[0]:B RBB[1]:B RBB[2]:B RBB[3]:B RBB[4]:B RBB[5]:B RBB[6]:B
*.pininfo RBB[7]:B RBB[8]:B RBB[9]:B RBB[10]:B RBB[11]:B RBB[12]:B RBB[13]:B
*.pininfo RBB[14]:B RBB[15]:B RBT[0]:B RBT[1]:B RBT[2]:B RBT[3]:B RBT[4]:B
*.pininfo RBT[5]:B RBT[6]:B RBT[7]:B RBT[8]:B RBT[9]:B RBT[10]:B RBT[11]:B
*.pininfo RBT[12]:B RBT[13]:B RBT[14]:B RBT[15]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B
*.pininfo RGRD3[2]:B RGRD3[3]:B RMO[0]:B RMO[1]:B RMO[2]:B VSB[0]:B VSB[1]:B
*.pininfo VSB[2]:B VSB[3]:B WMO[0]:B WMO[1]:B WMO[2]:B XARLSBA[0]:B
*.pininfo XARLSBA[1]:B XARLSBA[2]:B XARLSBA[3]:B XARMSBA[0]:B XARMSBA[1]:B
*.pininfo XARMSBA[2]:B XARMSBA[3]:B XARMSBB[0]:B XARMSBB[1]:B XARMSBB[2]:B
*.pininfo XARMSBB[3]:B VSS:B VSSX:B VDDA:B CSH_ENB:B BPUI:B SPUI:B ZRR:B
*.pininfo VNW:B DBL0:B LCLKB:B PWR:B ag_ctrl:B CSH_RR:B EN:B ENB:B T0EN:B
*.pininfo CSH_LD:B RWOUT:B RGD:B RGBW:B PD[0]:B PD[1]:B PD[2]:B PD[3]:B RWL:B
*.pininfo DBL:B
XXspram_4096x16m16b1pm2re1RE1M16_B1SBNK_0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+ BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+ BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+ BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+ BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+ BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+ BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+ BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+ BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+ BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+ BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+ BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+ BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+ BB[124] BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6]
+ BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17]
+ BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27]
+ BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37]
+ BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47]
+ BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+ BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67]
+ BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77]
+ BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87]
+ BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97]
+ BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106]
+ BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115]
+ BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124]
+ BT[125] BT[126] BT[127] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6]
+ GBW[7] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] VSS VSSX VDDA PD[0] PD[1] PD[2] PD[3] RWL DBL CSH_YS[0] CSH_YS[1]
+ CSH_YS[2] CSH_YS[3] LXWB[0] LXWB[1] LXWB[2] LXWB[3] QT[0] QT[1] QT[2] QT[3]
+ QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] RMO[0] RMO[1] RMO[2]
+ VSB[0] VSB[1] VSB[2] VSB[3] WMO[0] WMO[1] WMO[2] XARLSBA[0] XARLSBA[1]
+ XARLSBA[2] XARLSBA[3] XARMSBA[0] XARMSBA[1] XARMSBA[2] XARMSBA[3]
+ XARMSBB[0] XARMSBB[1] XARMSBB[2] XARMSBB[3] CSH_ENB BPUI SPUI ZRR VNW DBL0
+ LCLKB PWR ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT BB[128] BB[129] BB[130]
+ BB[131] BB[132] BB[133] BB[134] BB[135] BB[136] BB[137] BB[138] BB[139]
+ BB[140] BB[141] BB[142] BB[143] BB[144] BB[145] BB[146] BB[147] BB[148]
+ BB[149] BB[150] BB[151] BB[152] BB[153] BB[154] BB[155] BB[156] BB[157]
+ BB[158] BB[159] BB[160] BB[161] BB[162] BB[163] BB[164] BB[165] BB[166]
+ BB[167] BB[168] BB[169] BB[170] BB[171] BB[172] BB[173] BB[174] BB[175]
+ BB[176] BB[177] BB[178] BB[179] BB[180] BB[181] BB[182] BB[183] BB[184]
+ BB[185] BB[186] BB[187] BB[188] BB[189] BB[190] BB[191] BB[192] BB[193]
+ BB[194] BB[195] BB[196] BB[197] BB[198] BB[199] BB[200] BB[201] BB[202]
+ BB[203] BB[204] BB[205] BB[206] BB[207] BB[208] BB[209] BB[210] BB[211]
+ BB[212] BB[213] BB[214] BB[215] BB[216] BB[217] BB[218] BB[219] BB[220]
+ BB[221] BB[222] BB[223] BB[224] BB[225] BB[226] BB[227] BB[228] BB[229]
+ BB[230] BB[231] BB[232] BB[233] BB[234] BB[235] BB[236] BB[237] BB[238]
+ BB[239] BB[240] BB[241] BB[242] BB[243] BB[244] BB[245] BB[246] BB[247]
+ BB[248] BB[249] BB[250] BB[251] BB[252] BB[253] BB[254] BB[255] BT[128]
+ BT[129] BT[130] BT[131] BT[132] BT[133] BT[134] BT[135] BT[136] BT[137]
+ BT[138] BT[139] BT[140] BT[141] BT[142] BT[143] BT[144] BT[145] BT[146]
+ BT[147] BT[148] BT[149] BT[150] BT[151] BT[152] BT[153] BT[154] BT[155]
+ BT[156] BT[157] BT[158] BT[159] BT[160] BT[161] BT[162] BT[163] BT[164]
+ BT[165] BT[166] BT[167] BT[168] BT[169] BT[170] BT[171] BT[172] BT[173]
+ BT[174] BT[175] BT[176] BT[177] BT[178] BT[179] BT[180] BT[181] BT[182]
+ BT[183] BT[184] BT[185] BT[186] BT[187] BT[188] BT[189] BT[190] BT[191]
+ BT[192] BT[193] BT[194] BT[195] BT[196] BT[197] BT[198] BT[199] BT[200]
+ BT[201] BT[202] BT[203] BT[204] BT[205] BT[206] BT[207] BT[208] BT[209]
+ BT[210] BT[211] BT[212] BT[213] BT[214] BT[215] BT[216] BT[217] BT[218]
+ BT[219] BT[220] BT[221] BT[222] BT[223] BT[224] BT[225] BT[226] BT[227]
+ BT[228] BT[229] BT[230] BT[231] BT[232] BT[233] BT[234] BT[235] BT[236]
+ BT[237] BT[238] BT[239] BT[240] BT[241] BT[242] BT[243] BT[244] BT[245]
+ BT[246] BT[247] BT[248] BT[249] BT[250] BT[251] BT[252] BT[253] BT[254]
+ BT[255] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8]
+ GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34]
+ GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42]
+ GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50]
+ GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58]
+ GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34]
+ GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42]
+ GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50]
+ GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58]
+ GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34]
+ GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42]
+ GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50]
+ GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58]
+ GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] RBB[0] RBB[1] RBB[2] RBB[3]
+ RBB[4] RBB[5] RBB[6] RBB[7] RBB[8] RBB[9] RBB[10] RBB[11] RBB[12] RBB[13]
+ RBB[14] RBB[15] RBT[0] RBT[1] RBT[2] RBT[3] RBT[4] RBT[5] RBT[6] RBT[7]
+ RBT[8] RBT[9] RBT[10] RBT[11] RBT[12] RBT[13] RBT[14] RBT[15] RGRD0[0]
+ RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0]
+ RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RGD RGBW
+ spram_4096x16m16b1pm2re1RE1M16_B1SBNK m=1
.ends spram_4096x16m16b1pm2re1RE1M16_B1

.subckt spram_4096x16m16b1pm2re1BNK1_BK BBR[0] BBR[1] BBR[2] BBR[3] BBR[4]
+ BBR[5] BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14]
+ BBR[15] BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23]
+ BBR[24] BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32]
+ BBR[33] BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41]
+ BBR[42] BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50]
+ BBR[51] BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59]
+ BBR[60] BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68]
+ BBR[69] BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77]
+ BBR[78] BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86]
+ BBR[87] BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95]
+ BBR[96] BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103]
+ BBR[104] BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111]
+ BBR[112] BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119]
+ BBR[120] BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127]
+ BBR[128] BBR[129] BBR[130] BBR[131] BBR[132] BBR[133] BBR[134] BBR[135]
+ BBR[136] BBR[137] BBR[138] BBR[139] BBR[140] BBR[141] BBR[142] BBR[143]
+ BBR[144] BBR[145] BBR[146] BBR[147] BBR[148] BBR[149] BBR[150] BBR[151]
+ BBR[152] BBR[153] BBR[154] BBR[155] BBR[156] BBR[157] BBR[158] BBR[159]
+ BBR[160] BBR[161] BBR[162] BBR[163] BBR[164] BBR[165] BBR[166] BBR[167]
+ BBR[168] BBR[169] BBR[170] BBR[171] BBR[172] BBR[173] BBR[174] BBR[175]
+ BBR[176] BBR[177] BBR[178] BBR[179] BBR[180] BBR[181] BBR[182] BBR[183]
+ BBR[184] BBR[185] BBR[186] BBR[187] BBR[188] BBR[189] BBR[190] BBR[191]
+ BBR[192] BBR[193] BBR[194] BBR[195] BBR[196] BBR[197] BBR[198] BBR[199]
+ BBR[200] BBR[201] BBR[202] BBR[203] BBR[204] BBR[205] BBR[206] BBR[207]
+ BBR[208] BBR[209] BBR[210] BBR[211] BBR[212] BBR[213] BBR[214] BBR[215]
+ BBR[216] BBR[217] BBR[218] BBR[219] BBR[220] BBR[221] BBR[222] BBR[223]
+ BBR[224] BBR[225] BBR[226] BBR[227] BBR[228] BBR[229] BBR[230] BBR[231]
+ BBR[232] BBR[233] BBR[234] BBR[235] BBR[236] BBR[237] BBR[238] BBR[239]
+ BBR[240] BBR[241] BBR[242] BBR[243] BBR[244] BBR[245] BBR[246] BBR[247]
+ BBR[248] BBR[249] BBR[250] BBR[251] BBR[252] BBR[253] BBR[254] BBR[255]
+ BTR[0] BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9]
+ BTR[10] BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18]
+ BTR[19] BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27]
+ BTR[28] BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36]
+ BTR[37] BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45]
+ BTR[46] BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54]
+ BTR[55] BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63]
+ BTR[64] BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72]
+ BTR[73] BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81]
+ BTR[82] BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90]
+ BTR[91] BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99]
+ BTR[100] BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107]
+ BTR[108] BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115]
+ BTR[116] BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123]
+ BTR[124] BTR[125] BTR[126] BTR[127] BTR[128] BTR[129] BTR[130] BTR[131]
+ BTR[132] BTR[133] BTR[134] BTR[135] BTR[136] BTR[137] BTR[138] BTR[139]
+ BTR[140] BTR[141] BTR[142] BTR[143] BTR[144] BTR[145] BTR[146] BTR[147]
+ BTR[148] BTR[149] BTR[150] BTR[151] BTR[152] BTR[153] BTR[154] BTR[155]
+ BTR[156] BTR[157] BTR[158] BTR[159] BTR[160] BTR[161] BTR[162] BTR[163]
+ BTR[164] BTR[165] BTR[166] BTR[167] BTR[168] BTR[169] BTR[170] BTR[171]
+ BTR[172] BTR[173] BTR[174] BTR[175] BTR[176] BTR[177] BTR[178] BTR[179]
+ BTR[180] BTR[181] BTR[182] BTR[183] BTR[184] BTR[185] BTR[186] BTR[187]
+ BTR[188] BTR[189] BTR[190] BTR[191] BTR[192] BTR[193] BTR[194] BTR[195]
+ BTR[196] BTR[197] BTR[198] BTR[199] BTR[200] BTR[201] BTR[202] BTR[203]
+ BTR[204] BTR[205] BTR[206] BTR[207] BTR[208] BTR[209] BTR[210] BTR[211]
+ BTR[212] BTR[213] BTR[214] BTR[215] BTR[216] BTR[217] BTR[218] BTR[219]
+ BTR[220] BTR[221] BTR[222] BTR[223] BTR[224] BTR[225] BTR[226] BTR[227]
+ BTR[228] BTR[229] BTR[230] BTR[231] BTR[232] BTR[233] BTR[234] BTR[235]
+ BTR[236] BTR[237] BTR[238] BTR[239] BTR[240] BTR[241] BTR[242] BTR[243]
+ BTR[244] BTR[245] BTR[246] BTR[247] BTR[248] BTR[249] BTR[250] BTR[251]
+ BTR[252] BTR[253] BTR[254] BTR[255] CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3]
+ GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GBW[8] GBW[9]
+ GBW[10] GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[0] GD[1] GD[2] GD[3]
+ GD[4] GD[5] GD[6] GD[7] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14]
+ GD[15] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7]
+ GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15]
+ GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23]
+ GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31]
+ GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39]
+ GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47]
+ GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55]
+ GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63]
+ GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8]
+ GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16]
+ GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24]
+ GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD1[32]
+ GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40]
+ GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48]
+ GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56]
+ GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[0]
+ GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9]
+ GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17]
+ GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25]
+ GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD2[32] GRD2[33]
+ GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41]
+ GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49]
+ GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57]
+ GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[0] GRD3[1]
+ GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10]
+ GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18]
+ GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26]
+ GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] GRD3[32] GRD3[33] GRD3[34]
+ GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42]
+ GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50]
+ GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58]
+ GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] LXWB_R[0] LXWB_R[1] LXWB_R[2]
+ LXWB_R[3] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5]
+ RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13]
+ RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5]
+ RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13]
+ RBT_R[14] RBT_R[15] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RMO[0] RMO[1] RMO[2] VSB[1] VSB[2] VSB[3] VSB[4] WMO[0]
+ WMO[1] WMO[2] XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2] XARLSBA_R[3]
+ XARMSBA_R[0] XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] XARMSBB_R[0]
+ XARMSBB_R[1] XARMSBB_R[2] XARMSBB_R[3] VSS VSSX VDDA CSH_ENB BPUI SPUI ZRR
+ DBL0 LCLKB PWR ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT RGD RGBW
*.pininfo BBR[0]:B BBR[1]:B BBR[2]:B BBR[3]:B BBR[4]:B BBR[5]:B BBR[6]:B
*.pininfo BBR[7]:B BBR[8]:B BBR[9]:B BBR[10]:B BBR[11]:B BBR[12]:B BBR[13]:B
*.pininfo BBR[14]:B BBR[15]:B BBR[16]:B BBR[17]:B BBR[18]:B BBR[19]:B
*.pininfo BBR[20]:B BBR[21]:B BBR[22]:B BBR[23]:B BBR[24]:B BBR[25]:B
*.pininfo BBR[26]:B BBR[27]:B BBR[28]:B BBR[29]:B BBR[30]:B BBR[31]:B
*.pininfo BBR[32]:B BBR[33]:B BBR[34]:B BBR[35]:B BBR[36]:B BBR[37]:B
*.pininfo BBR[38]:B BBR[39]:B BBR[40]:B BBR[41]:B BBR[42]:B BBR[43]:B
*.pininfo BBR[44]:B BBR[45]:B BBR[46]:B BBR[47]:B BBR[48]:B BBR[49]:B
*.pininfo BBR[50]:B BBR[51]:B BBR[52]:B BBR[53]:B BBR[54]:B BBR[55]:B
*.pininfo BBR[56]:B BBR[57]:B BBR[58]:B BBR[59]:B BBR[60]:B BBR[61]:B
*.pininfo BBR[62]:B BBR[63]:B BBR[64]:B BBR[65]:B BBR[66]:B BBR[67]:B
*.pininfo BBR[68]:B BBR[69]:B BBR[70]:B BBR[71]:B BBR[72]:B BBR[73]:B
*.pininfo BBR[74]:B BBR[75]:B BBR[76]:B BBR[77]:B BBR[78]:B BBR[79]:B
*.pininfo BBR[80]:B BBR[81]:B BBR[82]:B BBR[83]:B BBR[84]:B BBR[85]:B
*.pininfo BBR[86]:B BBR[87]:B BBR[88]:B BBR[89]:B BBR[90]:B BBR[91]:B
*.pininfo BBR[92]:B BBR[93]:B BBR[94]:B BBR[95]:B BBR[96]:B BBR[97]:B
*.pininfo BBR[98]:B BBR[99]:B BBR[100]:B BBR[101]:B BBR[102]:B BBR[103]:B
*.pininfo BBR[104]:B BBR[105]:B BBR[106]:B BBR[107]:B BBR[108]:B BBR[109]:B
*.pininfo BBR[110]:B BBR[111]:B BBR[112]:B BBR[113]:B BBR[114]:B BBR[115]:B
*.pininfo BBR[116]:B BBR[117]:B BBR[118]:B BBR[119]:B BBR[120]:B BBR[121]:B
*.pininfo BBR[122]:B BBR[123]:B BBR[124]:B BBR[125]:B BBR[126]:B BBR[127]:B
*.pininfo BBR[128]:B BBR[129]:B BBR[130]:B BBR[131]:B BBR[132]:B BBR[133]:B
*.pininfo BBR[134]:B BBR[135]:B BBR[136]:B BBR[137]:B BBR[138]:B BBR[139]:B
*.pininfo BBR[140]:B BBR[141]:B BBR[142]:B BBR[143]:B BBR[144]:B BBR[145]:B
*.pininfo BBR[146]:B BBR[147]:B BBR[148]:B BBR[149]:B BBR[150]:B BBR[151]:B
*.pininfo BBR[152]:B BBR[153]:B BBR[154]:B BBR[155]:B BBR[156]:B BBR[157]:B
*.pininfo BBR[158]:B BBR[159]:B BBR[160]:B BBR[161]:B BBR[162]:B BBR[163]:B
*.pininfo BBR[164]:B BBR[165]:B BBR[166]:B BBR[167]:B BBR[168]:B BBR[169]:B
*.pininfo BBR[170]:B BBR[171]:B BBR[172]:B BBR[173]:B BBR[174]:B BBR[175]:B
*.pininfo BBR[176]:B BBR[177]:B BBR[178]:B BBR[179]:B BBR[180]:B BBR[181]:B
*.pininfo BBR[182]:B BBR[183]:B BBR[184]:B BBR[185]:B BBR[186]:B BBR[187]:B
*.pininfo BBR[188]:B BBR[189]:B BBR[190]:B BBR[191]:B BBR[192]:B BBR[193]:B
*.pininfo BBR[194]:B BBR[195]:B BBR[196]:B BBR[197]:B BBR[198]:B BBR[199]:B
*.pininfo BBR[200]:B BBR[201]:B BBR[202]:B BBR[203]:B BBR[204]:B BBR[205]:B
*.pininfo BBR[206]:B BBR[207]:B BBR[208]:B BBR[209]:B BBR[210]:B BBR[211]:B
*.pininfo BBR[212]:B BBR[213]:B BBR[214]:B BBR[215]:B BBR[216]:B BBR[217]:B
*.pininfo BBR[218]:B BBR[219]:B BBR[220]:B BBR[221]:B BBR[222]:B BBR[223]:B
*.pininfo BBR[224]:B BBR[225]:B BBR[226]:B BBR[227]:B BBR[228]:B BBR[229]:B
*.pininfo BBR[230]:B BBR[231]:B BBR[232]:B BBR[233]:B BBR[234]:B BBR[235]:B
*.pininfo BBR[236]:B BBR[237]:B BBR[238]:B BBR[239]:B BBR[240]:B BBR[241]:B
*.pininfo BBR[242]:B BBR[243]:B BBR[244]:B BBR[245]:B BBR[246]:B BBR[247]:B
*.pininfo BBR[248]:B BBR[249]:B BBR[250]:B BBR[251]:B BBR[252]:B BBR[253]:B
*.pininfo BBR[254]:B BBR[255]:B BTR[0]:B BTR[1]:B BTR[2]:B BTR[3]:B BTR[4]:B
*.pininfo BTR[5]:B BTR[6]:B BTR[7]:B BTR[8]:B BTR[9]:B BTR[10]:B BTR[11]:B
*.pininfo BTR[12]:B BTR[13]:B BTR[14]:B BTR[15]:B BTR[16]:B BTR[17]:B
*.pininfo BTR[18]:B BTR[19]:B BTR[20]:B BTR[21]:B BTR[22]:B BTR[23]:B
*.pininfo BTR[24]:B BTR[25]:B BTR[26]:B BTR[27]:B BTR[28]:B BTR[29]:B
*.pininfo BTR[30]:B BTR[31]:B BTR[32]:B BTR[33]:B BTR[34]:B BTR[35]:B
*.pininfo BTR[36]:B BTR[37]:B BTR[38]:B BTR[39]:B BTR[40]:B BTR[41]:B
*.pininfo BTR[42]:B BTR[43]:B BTR[44]:B BTR[45]:B BTR[46]:B BTR[47]:B
*.pininfo BTR[48]:B BTR[49]:B BTR[50]:B BTR[51]:B BTR[52]:B BTR[53]:B
*.pininfo BTR[54]:B BTR[55]:B BTR[56]:B BTR[57]:B BTR[58]:B BTR[59]:B
*.pininfo BTR[60]:B BTR[61]:B BTR[62]:B BTR[63]:B BTR[64]:B BTR[65]:B
*.pininfo BTR[66]:B BTR[67]:B BTR[68]:B BTR[69]:B BTR[70]:B BTR[71]:B
*.pininfo BTR[72]:B BTR[73]:B BTR[74]:B BTR[75]:B BTR[76]:B BTR[77]:B
*.pininfo BTR[78]:B BTR[79]:B BTR[80]:B BTR[81]:B BTR[82]:B BTR[83]:B
*.pininfo BTR[84]:B BTR[85]:B BTR[86]:B BTR[87]:B BTR[88]:B BTR[89]:B
*.pininfo BTR[90]:B BTR[91]:B BTR[92]:B BTR[93]:B BTR[94]:B BTR[95]:B
*.pininfo BTR[96]:B BTR[97]:B BTR[98]:B BTR[99]:B BTR[100]:B BTR[101]:B
*.pininfo BTR[102]:B BTR[103]:B BTR[104]:B BTR[105]:B BTR[106]:B BTR[107]:B
*.pininfo BTR[108]:B BTR[109]:B BTR[110]:B BTR[111]:B BTR[112]:B BTR[113]:B
*.pininfo BTR[114]:B BTR[115]:B BTR[116]:B BTR[117]:B BTR[118]:B BTR[119]:B
*.pininfo BTR[120]:B BTR[121]:B BTR[122]:B BTR[123]:B BTR[124]:B BTR[125]:B
*.pininfo BTR[126]:B BTR[127]:B BTR[128]:B BTR[129]:B BTR[130]:B BTR[131]:B
*.pininfo BTR[132]:B BTR[133]:B BTR[134]:B BTR[135]:B BTR[136]:B BTR[137]:B
*.pininfo BTR[138]:B BTR[139]:B BTR[140]:B BTR[141]:B BTR[142]:B BTR[143]:B
*.pininfo BTR[144]:B BTR[145]:B BTR[146]:B BTR[147]:B BTR[148]:B BTR[149]:B
*.pininfo BTR[150]:B BTR[151]:B BTR[152]:B BTR[153]:B BTR[154]:B BTR[155]:B
*.pininfo BTR[156]:B BTR[157]:B BTR[158]:B BTR[159]:B BTR[160]:B BTR[161]:B
*.pininfo BTR[162]:B BTR[163]:B BTR[164]:B BTR[165]:B BTR[166]:B BTR[167]:B
*.pininfo BTR[168]:B BTR[169]:B BTR[170]:B BTR[171]:B BTR[172]:B BTR[173]:B
*.pininfo BTR[174]:B BTR[175]:B BTR[176]:B BTR[177]:B BTR[178]:B BTR[179]:B
*.pininfo BTR[180]:B BTR[181]:B BTR[182]:B BTR[183]:B BTR[184]:B BTR[185]:B
*.pininfo BTR[186]:B BTR[187]:B BTR[188]:B BTR[189]:B BTR[190]:B BTR[191]:B
*.pininfo BTR[192]:B BTR[193]:B BTR[194]:B BTR[195]:B BTR[196]:B BTR[197]:B
*.pininfo BTR[198]:B BTR[199]:B BTR[200]:B BTR[201]:B BTR[202]:B BTR[203]:B
*.pininfo BTR[204]:B BTR[205]:B BTR[206]:B BTR[207]:B BTR[208]:B BTR[209]:B
*.pininfo BTR[210]:B BTR[211]:B BTR[212]:B BTR[213]:B BTR[214]:B BTR[215]:B
*.pininfo BTR[216]:B BTR[217]:B BTR[218]:B BTR[219]:B BTR[220]:B BTR[221]:B
*.pininfo BTR[222]:B BTR[223]:B BTR[224]:B BTR[225]:B BTR[226]:B BTR[227]:B
*.pininfo BTR[228]:B BTR[229]:B BTR[230]:B BTR[231]:B BTR[232]:B BTR[233]:B
*.pininfo BTR[234]:B BTR[235]:B BTR[236]:B BTR[237]:B BTR[238]:B BTR[239]:B
*.pininfo BTR[240]:B BTR[241]:B BTR[242]:B BTR[243]:B BTR[244]:B BTR[245]:B
*.pininfo BTR[246]:B BTR[247]:B BTR[248]:B BTR[249]:B BTR[250]:B BTR[251]:B
*.pininfo BTR[252]:B BTR[253]:B BTR[254]:B BTR[255]:B CSH_YS[0]:B CSH_YS[1]:B
*.pininfo CSH_YS[2]:B CSH_YS[3]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B
*.pininfo GBW[4]:B GBW[5]:B GBW[6]:B GBW[7]:B GBW[8]:B GBW[9]:B GBW[10]:B
*.pininfo GBW[11]:B GBW[12]:B GBW[13]:B GBW[14]:B GBW[15]:B GD[0]:B GD[1]:B
*.pininfo GD[2]:B GD[3]:B GD[4]:B GD[5]:B GD[6]:B GD[7]:B GD[8]:B GD[9]:B
*.pininfo GD[10]:B GD[11]:B GD[12]:B GD[13]:B GD[14]:B GD[15]:B GRD0[0]:B
*.pininfo GRD0[1]:B GRD0[2]:B GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B
*.pininfo GRD0[7]:B GRD0[8]:B GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B
*.pininfo GRD0[13]:B GRD0[14]:B GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B
*.pininfo GRD0[19]:B GRD0[20]:B GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B
*.pininfo GRD0[25]:B GRD0[26]:B GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B
*.pininfo GRD0[31]:B GRD0[32]:B GRD0[33]:B GRD0[34]:B GRD0[35]:B GRD0[36]:B
*.pininfo GRD0[37]:B GRD0[38]:B GRD0[39]:B GRD0[40]:B GRD0[41]:B GRD0[42]:B
*.pininfo GRD0[43]:B GRD0[44]:B GRD0[45]:B GRD0[46]:B GRD0[47]:B GRD0[48]:B
*.pininfo GRD0[49]:B GRD0[50]:B GRD0[51]:B GRD0[52]:B GRD0[53]:B GRD0[54]:B
*.pininfo GRD0[55]:B GRD0[56]:B GRD0[57]:B GRD0[58]:B GRD0[59]:B GRD0[60]:B
*.pininfo GRD0[61]:B GRD0[62]:B GRD0[63]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B
*.pininfo GRD1[3]:B GRD1[4]:B GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B
*.pininfo GRD1[9]:B GRD1[10]:B GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B
*.pininfo GRD1[15]:B GRD1[16]:B GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B
*.pininfo GRD1[21]:B GRD1[22]:B GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B
*.pininfo GRD1[27]:B GRD1[28]:B GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD1[32]:B
*.pininfo GRD1[33]:B GRD1[34]:B GRD1[35]:B GRD1[36]:B GRD1[37]:B GRD1[38]:B
*.pininfo GRD1[39]:B GRD1[40]:B GRD1[41]:B GRD1[42]:B GRD1[43]:B GRD1[44]:B
*.pininfo GRD1[45]:B GRD1[46]:B GRD1[47]:B GRD1[48]:B GRD1[49]:B GRD1[50]:B
*.pininfo GRD1[51]:B GRD1[52]:B GRD1[53]:B GRD1[54]:B GRD1[55]:B GRD1[56]:B
*.pininfo GRD1[57]:B GRD1[58]:B GRD1[59]:B GRD1[60]:B GRD1[61]:B GRD1[62]:B
*.pininfo GRD1[63]:B GRD2[0]:B GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B
*.pininfo GRD2[5]:B GRD2[6]:B GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B
*.pininfo GRD2[11]:B GRD2[12]:B GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B
*.pininfo GRD2[17]:B GRD2[18]:B GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B
*.pininfo GRD2[23]:B GRD2[24]:B GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B
*.pininfo GRD2[29]:B GRD2[30]:B GRD2[31]:B GRD2[32]:B GRD2[33]:B GRD2[34]:B
*.pininfo GRD2[35]:B GRD2[36]:B GRD2[37]:B GRD2[38]:B GRD2[39]:B GRD2[40]:B
*.pininfo GRD2[41]:B GRD2[42]:B GRD2[43]:B GRD2[44]:B GRD2[45]:B GRD2[46]:B
*.pininfo GRD2[47]:B GRD2[48]:B GRD2[49]:B GRD2[50]:B GRD2[51]:B GRD2[52]:B
*.pininfo GRD2[53]:B GRD2[54]:B GRD2[55]:B GRD2[56]:B GRD2[57]:B GRD2[58]:B
*.pininfo GRD2[59]:B GRD2[60]:B GRD2[61]:B GRD2[62]:B GRD2[63]:B GRD3[0]:B
*.pininfo GRD3[1]:B GRD3[2]:B GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B
*.pininfo GRD3[7]:B GRD3[8]:B GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B
*.pininfo GRD3[13]:B GRD3[14]:B GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B
*.pininfo GRD3[19]:B GRD3[20]:B GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B
*.pininfo GRD3[25]:B GRD3[26]:B GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B
*.pininfo GRD3[31]:B GRD3[32]:B GRD3[33]:B GRD3[34]:B GRD3[35]:B GRD3[36]:B
*.pininfo GRD3[37]:B GRD3[38]:B GRD3[39]:B GRD3[40]:B GRD3[41]:B GRD3[42]:B
*.pininfo GRD3[43]:B GRD3[44]:B GRD3[45]:B GRD3[46]:B GRD3[47]:B GRD3[48]:B
*.pininfo GRD3[49]:B GRD3[50]:B GRD3[51]:B GRD3[52]:B GRD3[53]:B GRD3[54]:B
*.pininfo GRD3[55]:B GRD3[56]:B GRD3[57]:B GRD3[58]:B GRD3[59]:B GRD3[60]:B
*.pininfo GRD3[61]:B GRD3[62]:B GRD3[63]:B LXWB_R[0]:B LXWB_R[1]:B
*.pininfo LXWB_R[2]:B LXWB_R[3]:B QT[2]:B QT[3]:B QT[4]:B QT[5]:B QT[6]:B
*.pininfo QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B QT[12]:B QT[13]:B
*.pininfo RBB_R[0]:B RBB_R[1]:B RBB_R[2]:B RBB_R[3]:B RBB_R[4]:B RBB_R[5]:B
*.pininfo RBB_R[6]:B RBB_R[7]:B RBB_R[8]:B RBB_R[9]:B RBB_R[10]:B RBB_R[11]:B
*.pininfo RBB_R[12]:B RBB_R[13]:B RBB_R[14]:B RBB_R[15]:B RBT_R[0]:B
*.pininfo RBT_R[1]:B RBT_R[2]:B RBT_R[3]:B RBT_R[4]:B RBT_R[5]:B RBT_R[6]:B
*.pininfo RBT_R[7]:B RBT_R[8]:B RBT_R[9]:B RBT_R[10]:B RBT_R[11]:B
*.pininfo RBT_R[12]:B RBT_R[13]:B RBT_R[14]:B RBT_R[15]:B RGRD0[0]:B
*.pininfo RGRD0[1]:B RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B
*.pininfo RGRD1[3]:B RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B
*.pininfo RGRD3[1]:B RGRD3[2]:B RGRD3[3]:B RMO[0]:B RMO[1]:B RMO[2]:B
*.pininfo VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B WMO[0]:B WMO[1]:B WMO[2]:B
*.pininfo XARLSBA_R[0]:B XARLSBA_R[1]:B XARLSBA_R[2]:B XARLSBA_R[3]:B
*.pininfo XARMSBA_R[0]:B XARMSBA_R[1]:B XARMSBA_R[2]:B XARMSBA_R[3]:B
*.pininfo XARMSBB_R[0]:B XARMSBB_R[1]:B XARMSBB_R[2]:B XARMSBB_R[3]:B VSS:B
*.pininfo VSSX:B VDDA:B CSH_ENB:B BPUI:B SPUI:B ZRR:B DBL0:B LCLKB:B PWR:B
*.pininfo ag_ctrl:B CSH_RR:B EN:B ENB:B T0EN:B CSH_LD:B RWOUT:B RGD:B RGBW:B
XXBNK1_BK BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6] BBR[7] BBR[8]
+ BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15] BBR[16] BBR[17]
+ BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24] BBR[25] BBR[26]
+ BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33] BBR[34] BBR[35]
+ BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42] BBR[43] BBR[44]
+ BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51] BBR[52] BBR[53]
+ BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60] BBR[61] BBR[62]
+ BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69] BBR[70] BBR[71]
+ BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78] BBR[79] BBR[80]
+ BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87] BBR[88] BBR[89]
+ BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96] BBR[97] BBR[98]
+ BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104] BBR[105] BBR[106]
+ BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112] BBR[113] BBR[114]
+ BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120] BBR[121] BBR[122]
+ BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BBR[128] BBR[129] BBR[130]
+ BBR[131] BBR[132] BBR[133] BBR[134] BBR[135] BBR[136] BBR[137] BBR[138]
+ BBR[139] BBR[140] BBR[141] BBR[142] BBR[143] BBR[144] BBR[145] BBR[146]
+ BBR[147] BBR[148] BBR[149] BBR[150] BBR[151] BBR[152] BBR[153] BBR[154]
+ BBR[155] BBR[156] BBR[157] BBR[158] BBR[159] BBR[160] BBR[161] BBR[162]
+ BBR[163] BBR[164] BBR[165] BBR[166] BBR[167] BBR[168] BBR[169] BBR[170]
+ BBR[171] BBR[172] BBR[173] BBR[174] BBR[175] BBR[176] BBR[177] BBR[178]
+ BBR[179] BBR[180] BBR[181] BBR[182] BBR[183] BBR[184] BBR[185] BBR[186]
+ BBR[187] BBR[188] BBR[189] BBR[190] BBR[191] BBR[192] BBR[193] BBR[194]
+ BBR[195] BBR[196] BBR[197] BBR[198] BBR[199] BBR[200] BBR[201] BBR[202]
+ BBR[203] BBR[204] BBR[205] BBR[206] BBR[207] BBR[208] BBR[209] BBR[210]
+ BBR[211] BBR[212] BBR[213] BBR[214] BBR[215] BBR[216] BBR[217] BBR[218]
+ BBR[219] BBR[220] BBR[221] BBR[222] BBR[223] BBR[224] BBR[225] BBR[226]
+ BBR[227] BBR[228] BBR[229] BBR[230] BBR[231] BBR[232] BBR[233] BBR[234]
+ BBR[235] BBR[236] BBR[237] BBR[238] BBR[239] BBR[240] BBR[241] BBR[242]
+ BBR[243] BBR[244] BBR[245] BBR[246] BBR[247] BBR[248] BBR[249] BBR[250]
+ BBR[251] BBR[252] BBR[253] BBR[254] BBR[255] BTR[0] BTR[1] BTR[2] BTR[3]
+ BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10] BTR[11] BTR[12] BTR[13]
+ BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19] BTR[20] BTR[21] BTR[22]
+ BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28] BTR[29] BTR[30] BTR[31]
+ BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37] BTR[38] BTR[39] BTR[40]
+ BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46] BTR[47] BTR[48] BTR[49]
+ BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55] BTR[56] BTR[57] BTR[58]
+ BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64] BTR[65] BTR[66] BTR[67]
+ BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73] BTR[74] BTR[75] BTR[76]
+ BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82] BTR[83] BTR[84] BTR[85]
+ BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91] BTR[92] BTR[93] BTR[94]
+ BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100] BTR[101] BTR[102] BTR[103]
+ BTR[104] BTR[105] BTR[106] BTR[107] BTR[108] BTR[109] BTR[110] BTR[111]
+ BTR[112] BTR[113] BTR[114] BTR[115] BTR[116] BTR[117] BTR[118] BTR[119]
+ BTR[120] BTR[121] BTR[122] BTR[123] BTR[124] BTR[125] BTR[126] BTR[127]
+ BTR[128] BTR[129] BTR[130] BTR[131] BTR[132] BTR[133] BTR[134] BTR[135]
+ BTR[136] BTR[137] BTR[138] BTR[139] BTR[140] BTR[141] BTR[142] BTR[143]
+ BTR[144] BTR[145] BTR[146] BTR[147] BTR[148] BTR[149] BTR[150] BTR[151]
+ BTR[152] BTR[153] BTR[154] BTR[155] BTR[156] BTR[157] BTR[158] BTR[159]
+ BTR[160] BTR[161] BTR[162] BTR[163] BTR[164] BTR[165] BTR[166] BTR[167]
+ BTR[168] BTR[169] BTR[170] BTR[171] BTR[172] BTR[173] BTR[174] BTR[175]
+ BTR[176] BTR[177] BTR[178] BTR[179] BTR[180] BTR[181] BTR[182] BTR[183]
+ BTR[184] BTR[185] BTR[186] BTR[187] BTR[188] BTR[189] BTR[190] BTR[191]
+ BTR[192] BTR[193] BTR[194] BTR[195] BTR[196] BTR[197] BTR[198] BTR[199]
+ BTR[200] BTR[201] BTR[202] BTR[203] BTR[204] BTR[205] BTR[206] BTR[207]
+ BTR[208] BTR[209] BTR[210] BTR[211] BTR[212] BTR[213] BTR[214] BTR[215]
+ BTR[216] BTR[217] BTR[218] BTR[219] BTR[220] BTR[221] BTR[222] BTR[223]
+ BTR[224] BTR[225] BTR[226] BTR[227] BTR[228] BTR[229] BTR[230] BTR[231]
+ BTR[232] BTR[233] BTR[234] BTR[235] BTR[236] BTR[237] BTR[238] BTR[239]
+ BTR[240] BTR[241] BTR[242] BTR[243] BTR[244] BTR[245] BTR[246] BTR[247]
+ BTR[248] BTR[249] BTR[250] BTR[251] BTR[252] BTR[253] BTR[254] BTR[255]
+ CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0] GBW[1] GBW[2] GBW[3] GBW[4]
+ GBW[5] GBW[6] GBW[7] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12] GBW[13] GBW[14]
+ GBW[15] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7] GD[8] GD[9] GD[10]
+ GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4]
+ GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37]
+ GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45]
+ GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53]
+ GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61]
+ GRD0[62] GRD0[63] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37] GRD1[38]
+ GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45] GRD1[46]
+ GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53] GRD1[54]
+ GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61] GRD1[62]
+ GRD1[63] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37] GRD2[38] GRD2[39]
+ GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45] GRD2[46] GRD2[47]
+ GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53] GRD2[54] GRD2[55]
+ GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61] GRD2[62] GRD2[63]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] GRD3[32]
+ GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38] GRD3[39] GRD3[40]
+ GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46] GRD3[47] GRD3[48]
+ GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54] GRD3[55] GRD3[56]
+ GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62] GRD3[63] LXWB_R[0]
+ LXWB_R[1] LXWB_R[2] LXWB_R[3] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+ QT[9] QT[10] QT[11] QT[12] QT[13] RBB_R[0] RBB_R[1] RBB_R[2] RBB_R[3]
+ RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9] RBB_R[10] RBB_R[11]
+ RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3]
+ RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11]
+ RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3]
+ RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3]
+ RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3] RMO[0] RMO[1] RMO[2] VSB[1] VSB[2]
+ VSB[3] VSB[4] WMO[0] WMO[1] WMO[2] XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2]
+ XARLSBA_R[3] XARMSBA_R[0] XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3]
+ XARMSBB_R[0] XARMSBB_R[1] XARMSBB_R[2] XARMSBB_R[3] VSS VSSX VDDA CSH_ENB
+ BPUI SPUI ZRR VDDA DBL0 LCLKB PWR ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT
+ RGD RGBW PD[0] PD[1] PD[2] PD[3] RWL DBL
+ spram_4096x16m16b1pm2re1RE1M16_B1 m=1
.ends spram_4096x16m16b1pm2re1BNK1_BK

.subckt spram_4096x16m16b1pm2re1BNK1 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4]
+ BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13]
+ BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21]
+ BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29]
+ BBMX[30] BBMX[31] BBMX[32] BBMX[33] BBMX[34] BBMX[35] BBMX[36] BBMX[37]
+ BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42] BBMX[43] BBMX[44] BBMX[45]
+ BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50] BBMX[51] BBMX[52] BBMX[53]
+ BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58] BBMX[59] BBMX[60] BBMX[61]
+ BBMX[62] BBMX[63] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6]
+ BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14]
+ BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22]
+ BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30]
+ BTMX[31] BTMX[32] BTMX[33] BTMX[34] BTMX[35] BTMX[36] BTMX[37] BTMX[38]
+ BTMX[39] BTMX[40] BTMX[41] BTMX[42] BTMX[43] BTMX[44] BTMX[45] BTMX[46]
+ BTMX[47] BTMX[48] BTMX[49] BTMX[50] BTMX[51] BTMX[52] BTMX[53] BTMX[54]
+ BTMX[55] BTMX[56] BTMX[57] BTMX[58] BTMX[59] BTMX[60] BTMX[61] BTMX[62]
+ BTMX[63] CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0] GBW[1] GBW[2]
+ GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12]
+ GBW[13] GBW[14] GBW[15] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD1[32] GRD1[33] GRD1[34] GRD1[35]
+ GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43]
+ GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51]
+ GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59]
+ GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8]
+ LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17]
+ LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26]
+ LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDB[32] LDB[33] LDB[34] LDB[35]
+ LDB[36] LDB[37] LDB[38] LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44]
+ LDB[45] LDB[46] LDB[47] LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53]
+ LDB[54] LDB[55] LDB[56] LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62]
+ LDB[63] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8]
+ LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17]
+ LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26]
+ LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] LDT[32] LDT[33] LDT[34] LDT[35]
+ LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43] LDT[44]
+ LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52] LDT[53]
+ LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61] LDT[62]
+ LDT[63] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1]
+ RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2]
+ RLDT[3] RMO[0] RMO[1] RMO[2] VSB[1] VSB[2] VSB[3] VSB[4] WMO[0] WMO[1]
+ WMO[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2]
+ XC[3] XWB[0] XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] VSS VDDA
+ PWR VSSX CSH_LD GRST CSH_RR ag_ctrl BPUI ZRR LRST WLRST SPUI RWOUT EN
+ CSH_ENB T0EN ENB RGD RGBW
*.pininfo BBMX[0]:B BBMX[1]:B BBMX[2]:B BBMX[3]:B BBMX[4]:B BBMX[5]:B
*.pininfo BBMX[6]:B BBMX[7]:B BBMX[8]:B BBMX[9]:B BBMX[10]:B BBMX[11]:B
*.pininfo BBMX[12]:B BBMX[13]:B BBMX[14]:B BBMX[15]:B BBMX[16]:B BBMX[17]:B
*.pininfo BBMX[18]:B BBMX[19]:B BBMX[20]:B BBMX[21]:B BBMX[22]:B BBMX[23]:B
*.pininfo BBMX[24]:B BBMX[25]:B BBMX[26]:B BBMX[27]:B BBMX[28]:B BBMX[29]:B
*.pininfo BBMX[30]:B BBMX[31]:B BBMX[32]:B BBMX[33]:B BBMX[34]:B BBMX[35]:B
*.pininfo BBMX[36]:B BBMX[37]:B BBMX[38]:B BBMX[39]:B BBMX[40]:B BBMX[41]:B
*.pininfo BBMX[42]:B BBMX[43]:B BBMX[44]:B BBMX[45]:B BBMX[46]:B BBMX[47]:B
*.pininfo BBMX[48]:B BBMX[49]:B BBMX[50]:B BBMX[51]:B BBMX[52]:B BBMX[53]:B
*.pininfo BBMX[54]:B BBMX[55]:B BBMX[56]:B BBMX[57]:B BBMX[58]:B BBMX[59]:B
*.pininfo BBMX[60]:B BBMX[61]:B BBMX[62]:B BBMX[63]:B BTMX[0]:B BTMX[1]:B
*.pininfo BTMX[2]:B BTMX[3]:B BTMX[4]:B BTMX[5]:B BTMX[6]:B BTMX[7]:B
*.pininfo BTMX[8]:B BTMX[9]:B BTMX[10]:B BTMX[11]:B BTMX[12]:B BTMX[13]:B
*.pininfo BTMX[14]:B BTMX[15]:B BTMX[16]:B BTMX[17]:B BTMX[18]:B BTMX[19]:B
*.pininfo BTMX[20]:B BTMX[21]:B BTMX[22]:B BTMX[23]:B BTMX[24]:B BTMX[25]:B
*.pininfo BTMX[26]:B BTMX[27]:B BTMX[28]:B BTMX[29]:B BTMX[30]:B BTMX[31]:B
*.pininfo BTMX[32]:B BTMX[33]:B BTMX[34]:B BTMX[35]:B BTMX[36]:B BTMX[37]:B
*.pininfo BTMX[38]:B BTMX[39]:B BTMX[40]:B BTMX[41]:B BTMX[42]:B BTMX[43]:B
*.pininfo BTMX[44]:B BTMX[45]:B BTMX[46]:B BTMX[47]:B BTMX[48]:B BTMX[49]:B
*.pininfo BTMX[50]:B BTMX[51]:B BTMX[52]:B BTMX[53]:B BTMX[54]:B BTMX[55]:B
*.pininfo BTMX[56]:B BTMX[57]:B BTMX[58]:B BTMX[59]:B BTMX[60]:B BTMX[61]:B
*.pininfo BTMX[62]:B BTMX[63]:B CSH_YS[0]:B CSH_YS[1]:B CSH_YS[2]:B
*.pininfo CSH_YS[3]:B GBW[0]:B GBW[1]:B GBW[2]:B GBW[3]:B GBW[4]:B GBW[5]:B
*.pininfo GBW[6]:B GBW[7]:B GBW[8]:B GBW[9]:B GBW[10]:B GBW[11]:B GBW[12]:B
*.pininfo GBW[13]:B GBW[14]:B GBW[15]:B GD[0]:B GD[1]:B GD[2]:B GD[3]:B
*.pininfo GD[4]:B GD[5]:B GD[6]:B GD[7]:B GD[8]:B GD[9]:B GD[10]:B GD[11]:B
*.pininfo GD[12]:B GD[13]:B GD[14]:B GD[15]:B GRD0[0]:B GRD0[1]:B GRD0[2]:B
*.pininfo GRD0[3]:B GRD0[4]:B GRD0[5]:B GRD0[6]:B GRD0[7]:B GRD0[8]:B
*.pininfo GRD0[9]:B GRD0[10]:B GRD0[11]:B GRD0[12]:B GRD0[13]:B GRD0[14]:B
*.pininfo GRD0[15]:B GRD0[16]:B GRD0[17]:B GRD0[18]:B GRD0[19]:B GRD0[20]:B
*.pininfo GRD0[21]:B GRD0[22]:B GRD0[23]:B GRD0[24]:B GRD0[25]:B GRD0[26]:B
*.pininfo GRD0[27]:B GRD0[28]:B GRD0[29]:B GRD0[30]:B GRD0[31]:B GRD0[32]:B
*.pininfo GRD0[33]:B GRD0[34]:B GRD0[35]:B GRD0[36]:B GRD0[37]:B GRD0[38]:B
*.pininfo GRD0[39]:B GRD0[40]:B GRD0[41]:B GRD0[42]:B GRD0[43]:B GRD0[44]:B
*.pininfo GRD0[45]:B GRD0[46]:B GRD0[47]:B GRD0[48]:B GRD0[49]:B GRD0[50]:B
*.pininfo GRD0[51]:B GRD0[52]:B GRD0[53]:B GRD0[54]:B GRD0[55]:B GRD0[56]:B
*.pininfo GRD0[57]:B GRD0[58]:B GRD0[59]:B GRD0[60]:B GRD0[61]:B GRD0[62]:B
*.pininfo GRD0[63]:B GRD1[0]:B GRD1[1]:B GRD1[2]:B GRD1[3]:B GRD1[4]:B
*.pininfo GRD1[5]:B GRD1[6]:B GRD1[7]:B GRD1[8]:B GRD1[9]:B GRD1[10]:B
*.pininfo GRD1[11]:B GRD1[12]:B GRD1[13]:B GRD1[14]:B GRD1[15]:B GRD1[16]:B
*.pininfo GRD1[17]:B GRD1[18]:B GRD1[19]:B GRD1[20]:B GRD1[21]:B GRD1[22]:B
*.pininfo GRD1[23]:B GRD1[24]:B GRD1[25]:B GRD1[26]:B GRD1[27]:B GRD1[28]:B
*.pininfo GRD1[29]:B GRD1[30]:B GRD1[31]:B GRD1[32]:B GRD1[33]:B GRD1[34]:B
*.pininfo GRD1[35]:B GRD1[36]:B GRD1[37]:B GRD1[38]:B GRD1[39]:B GRD1[40]:B
*.pininfo GRD1[41]:B GRD1[42]:B GRD1[43]:B GRD1[44]:B GRD1[45]:B GRD1[46]:B
*.pininfo GRD1[47]:B GRD1[48]:B GRD1[49]:B GRD1[50]:B GRD1[51]:B GRD1[52]:B
*.pininfo GRD1[53]:B GRD1[54]:B GRD1[55]:B GRD1[56]:B GRD1[57]:B GRD1[58]:B
*.pininfo GRD1[59]:B GRD1[60]:B GRD1[61]:B GRD1[62]:B GRD1[63]:B GRD2[0]:B
*.pininfo GRD2[1]:B GRD2[2]:B GRD2[3]:B GRD2[4]:B GRD2[5]:B GRD2[6]:B
*.pininfo GRD2[7]:B GRD2[8]:B GRD2[9]:B GRD2[10]:B GRD2[11]:B GRD2[12]:B
*.pininfo GRD2[13]:B GRD2[14]:B GRD2[15]:B GRD2[16]:B GRD2[17]:B GRD2[18]:B
*.pininfo GRD2[19]:B GRD2[20]:B GRD2[21]:B GRD2[22]:B GRD2[23]:B GRD2[24]:B
*.pininfo GRD2[25]:B GRD2[26]:B GRD2[27]:B GRD2[28]:B GRD2[29]:B GRD2[30]:B
*.pininfo GRD2[31]:B GRD2[32]:B GRD2[33]:B GRD2[34]:B GRD2[35]:B GRD2[36]:B
*.pininfo GRD2[37]:B GRD2[38]:B GRD2[39]:B GRD2[40]:B GRD2[41]:B GRD2[42]:B
*.pininfo GRD2[43]:B GRD2[44]:B GRD2[45]:B GRD2[46]:B GRD2[47]:B GRD2[48]:B
*.pininfo GRD2[49]:B GRD2[50]:B GRD2[51]:B GRD2[52]:B GRD2[53]:B GRD2[54]:B
*.pininfo GRD2[55]:B GRD2[56]:B GRD2[57]:B GRD2[58]:B GRD2[59]:B GRD2[60]:B
*.pininfo GRD2[61]:B GRD2[62]:B GRD2[63]:B GRD3[0]:B GRD3[1]:B GRD3[2]:B
*.pininfo GRD3[3]:B GRD3[4]:B GRD3[5]:B GRD3[6]:B GRD3[7]:B GRD3[8]:B
*.pininfo GRD3[9]:B GRD3[10]:B GRD3[11]:B GRD3[12]:B GRD3[13]:B GRD3[14]:B
*.pininfo GRD3[15]:B GRD3[16]:B GRD3[17]:B GRD3[18]:B GRD3[19]:B GRD3[20]:B
*.pininfo GRD3[21]:B GRD3[22]:B GRD3[23]:B GRD3[24]:B GRD3[25]:B GRD3[26]:B
*.pininfo GRD3[27]:B GRD3[28]:B GRD3[29]:B GRD3[30]:B GRD3[31]:B GRD3[32]:B
*.pininfo GRD3[33]:B GRD3[34]:B GRD3[35]:B GRD3[36]:B GRD3[37]:B GRD3[38]:B
*.pininfo GRD3[39]:B GRD3[40]:B GRD3[41]:B GRD3[42]:B GRD3[43]:B GRD3[44]:B
*.pininfo GRD3[45]:B GRD3[46]:B GRD3[47]:B GRD3[48]:B GRD3[49]:B GRD3[50]:B
*.pininfo GRD3[51]:B GRD3[52]:B GRD3[53]:B GRD3[54]:B GRD3[55]:B GRD3[56]:B
*.pininfo GRD3[57]:B GRD3[58]:B GRD3[59]:B GRD3[60]:B GRD3[61]:B GRD3[62]:B
*.pininfo GRD3[63]:B LDB[0]:B LDB[1]:B LDB[2]:B LDB[3]:B LDB[4]:B LDB[5]:B
*.pininfo LDB[6]:B LDB[7]:B LDB[8]:B LDB[9]:B LDB[10]:B LDB[11]:B LDB[12]:B
*.pininfo LDB[13]:B LDB[14]:B LDB[15]:B LDB[16]:B LDB[17]:B LDB[18]:B
*.pininfo LDB[19]:B LDB[20]:B LDB[21]:B LDB[22]:B LDB[23]:B LDB[24]:B
*.pininfo LDB[25]:B LDB[26]:B LDB[27]:B LDB[28]:B LDB[29]:B LDB[30]:B
*.pininfo LDB[31]:B LDB[32]:B LDB[33]:B LDB[34]:B LDB[35]:B LDB[36]:B
*.pininfo LDB[37]:B LDB[38]:B LDB[39]:B LDB[40]:B LDB[41]:B LDB[42]:B
*.pininfo LDB[43]:B LDB[44]:B LDB[45]:B LDB[46]:B LDB[47]:B LDB[48]:B
*.pininfo LDB[49]:B LDB[50]:B LDB[51]:B LDB[52]:B LDB[53]:B LDB[54]:B
*.pininfo LDB[55]:B LDB[56]:B LDB[57]:B LDB[58]:B LDB[59]:B LDB[60]:B
*.pininfo LDB[61]:B LDB[62]:B LDB[63]:B LDT[0]:B LDT[1]:B LDT[2]:B LDT[3]:B
*.pininfo LDT[4]:B LDT[5]:B LDT[6]:B LDT[7]:B LDT[8]:B LDT[9]:B LDT[10]:B
*.pininfo LDT[11]:B LDT[12]:B LDT[13]:B LDT[14]:B LDT[15]:B LDT[16]:B
*.pininfo LDT[17]:B LDT[18]:B LDT[19]:B LDT[20]:B LDT[21]:B LDT[22]:B
*.pininfo LDT[23]:B LDT[24]:B LDT[25]:B LDT[26]:B LDT[27]:B LDT[28]:B
*.pininfo LDT[29]:B LDT[30]:B LDT[31]:B LDT[32]:B LDT[33]:B LDT[34]:B
*.pininfo LDT[35]:B LDT[36]:B LDT[37]:B LDT[38]:B LDT[39]:B LDT[40]:B
*.pininfo LDT[41]:B LDT[42]:B LDT[43]:B LDT[44]:B LDT[45]:B LDT[46]:B
*.pininfo LDT[47]:B LDT[48]:B LDT[49]:B LDT[50]:B LDT[51]:B LDT[52]:B
*.pininfo LDT[53]:B LDT[54]:B LDT[55]:B LDT[56]:B LDT[57]:B LDT[58]:B
*.pininfo LDT[59]:B LDT[60]:B LDT[61]:B LDT[62]:B LDT[63]:B QT[2]:B QT[3]:B
*.pininfo QT[4]:B QT[5]:B QT[6]:B QT[7]:B QT[8]:B QT[9]:B QT[10]:B QT[11]:B
*.pininfo QT[12]:B QT[13]:B RBBMX[0]:B RBBMX[1]:B RBBMX[2]:B RBBMX[3]:B
*.pininfo RBTMX[0]:B RBTMX[1]:B RBTMX[2]:B RBTMX[3]:B RGRD0[0]:B RGRD0[1]:B
*.pininfo RGRD0[2]:B RGRD0[3]:B RGRD1[0]:B RGRD1[1]:B RGRD1[2]:B RGRD1[3]:B
*.pininfo RGRD2[0]:B RGRD2[1]:B RGRD2[2]:B RGRD2[3]:B RGRD3[0]:B RGRD3[1]:B
*.pininfo RGRD3[2]:B RGRD3[3]:B RLDB[0]:B RLDB[1]:B RLDB[2]:B RLDB[3]:B
*.pininfo RLDT[0]:B RLDT[1]:B RLDT[2]:B RLDT[3]:B RMO[0]:B RMO[1]:B RMO[2]:B
*.pininfo VSB[1]:B VSB[2]:B VSB[3]:B VSB[4]:B WMO[0]:B WMO[1]:B WMO[2]:B
*.pininfo XA[0]:B XA[1]:B XA[2]:B XA[3]:B XB[0]:B XB[1]:B XB[2]:B XB[3]:B
*.pininfo XC[0]:B XC[1]:B XC[2]:B XC[3]:B XWB[0]:B XWB[1]:B XWB[2]:B XWB[3]:B
*.pininfo YSEL[0]:B YSEL[1]:B YSEL[2]:B YSEL[3]:B VSS:B VDDA:B PWR:B VSSX:B
*.pininfo CSH_LD:B GRST:B CSH_RR:B ag_ctrl:B BPUI:B ZRR:B LRST:B WLRST:B
*.pininfo SPUI:B RWOUT:B EN:B CSH_ENB:B T0EN:B ENB:B RGD:B RGBW:B
XXspram_4096x16m16b1pm2re1BNK1_SLIO_0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4]
+ BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13]
+ BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21]
+ BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29]
+ BBMX[30] BBMX[31] BBMX[32] BBMX[33] BBMX[34] BBMX[35] BBMX[36] BBMX[37]
+ BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42] BBMX[43] BBMX[44] BBMX[45]
+ BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50] BBMX[51] BBMX[52] BBMX[53]
+ BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58] BBMX[59] BBMX[60] BBMX[61]
+ BBMX[62] BBMX[63] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6]
+ BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14]
+ BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22]
+ BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30]
+ BTMX[31] BTMX[32] BTMX[33] BTMX[34] BTMX[35] BTMX[36] BTMX[37] BTMX[38]
+ BTMX[39] BTMX[40] BTMX[41] BTMX[42] BTMX[43] BTMX[44] BTMX[45] BTMX[46]
+ BTMX[47] BTMX[48] BTMX[49] BTMX[50] BTMX[51] BTMX[52] BTMX[53] BTMX[54]
+ BTMX[55] BTMX[56] BTMX[57] BTMX[58] BTMX[59] BTMX[60] BTMX[61] BTMX[62]
+ BTMX[63] CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0] GBW[1] GBW[2]
+ GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12]
+ GBW[13] GBW[14] GBW[15] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD1[32] GRD1[33] GRD1[34] GRD1[35]
+ GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43]
+ GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51]
+ GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59]
+ GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8]
+ LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17]
+ LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26]
+ LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDB[32] LDB[33] LDB[34] LDB[35]
+ LDB[36] LDB[37] LDB[38] LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44]
+ LDB[45] LDB[46] LDB[47] LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53]
+ LDB[54] LDB[55] LDB[56] LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62]
+ LDB[63] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8]
+ LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17]
+ LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26]
+ LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] LDT[32] LDT[33] LDT[34] LDT[35]
+ LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43] LDT[44]
+ LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52] LDT[53]
+ LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61] LDT[62]
+ LDT[63] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1]
+ RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2]
+ RLDT[3] RMO[0] RMO[1] RMO[2] VSB[1] VSB[2] VSB[3] VSB[4] WMO[0] WMO[1]
+ WMO[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2]
+ XC[3] XWB[0] XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] VSS VDDA
+ PWR VSSX CSH_LD GRST CSH_RR ag_ctrl BPUI ZRR LRST WLRST SPUI RWOUT EN
+ CSH_ENB T0EN ENB RGD RGBW BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5] BBR[6]
+ BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24]
+ BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33]
+ BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42]
+ BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69]
+ BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78]
+ BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87]
+ BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96]
+ BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104]
+ BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112]
+ BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120]
+ BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BBR[128]
+ BBR[129] BBR[130] BBR[131] BBR[132] BBR[133] BBR[134] BBR[135] BBR[136]
+ BBR[137] BBR[138] BBR[139] BBR[140] BBR[141] BBR[142] BBR[143] BBR[144]
+ BBR[145] BBR[146] BBR[147] BBR[148] BBR[149] BBR[150] BBR[151] BBR[152]
+ BBR[153] BBR[154] BBR[155] BBR[156] BBR[157] BBR[158] BBR[159] BBR[160]
+ BBR[161] BBR[162] BBR[163] BBR[164] BBR[165] BBR[166] BBR[167] BBR[168]
+ BBR[169] BBR[170] BBR[171] BBR[172] BBR[173] BBR[174] BBR[175] BBR[176]
+ BBR[177] BBR[178] BBR[179] BBR[180] BBR[181] BBR[182] BBR[183] BBR[184]
+ BBR[185] BBR[186] BBR[187] BBR[188] BBR[189] BBR[190] BBR[191] BBR[192]
+ BBR[193] BBR[194] BBR[195] BBR[196] BBR[197] BBR[198] BBR[199] BBR[200]
+ BBR[201] BBR[202] BBR[203] BBR[204] BBR[205] BBR[206] BBR[207] BBR[208]
+ BBR[209] BBR[210] BBR[211] BBR[212] BBR[213] BBR[214] BBR[215] BBR[216]
+ BBR[217] BBR[218] BBR[219] BBR[220] BBR[221] BBR[222] BBR[223] BBR[224]
+ BBR[225] BBR[226] BBR[227] BBR[228] BBR[229] BBR[230] BBR[231] BBR[232]
+ BBR[233] BBR[234] BBR[235] BBR[236] BBR[237] BBR[238] BBR[239] BBR[240]
+ BBR[241] BBR[242] BBR[243] BBR[244] BBR[245] BBR[246] BBR[247] BBR[248]
+ BBR[249] BBR[250] BBR[251] BBR[252] BBR[253] BBR[254] BBR[255] BTR[0]
+ BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10]
+ BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19]
+ BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28]
+ BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37]
+ BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46]
+ BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55]
+ BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82]
+ BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91]
+ BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127] BTR[128] BTR[129] BTR[130] BTR[131] BTR[132]
+ BTR[133] BTR[134] BTR[135] BTR[136] BTR[137] BTR[138] BTR[139] BTR[140]
+ BTR[141] BTR[142] BTR[143] BTR[144] BTR[145] BTR[146] BTR[147] BTR[148]
+ BTR[149] BTR[150] BTR[151] BTR[152] BTR[153] BTR[154] BTR[155] BTR[156]
+ BTR[157] BTR[158] BTR[159] BTR[160] BTR[161] BTR[162] BTR[163] BTR[164]
+ BTR[165] BTR[166] BTR[167] BTR[168] BTR[169] BTR[170] BTR[171] BTR[172]
+ BTR[173] BTR[174] BTR[175] BTR[176] BTR[177] BTR[178] BTR[179] BTR[180]
+ BTR[181] BTR[182] BTR[183] BTR[184] BTR[185] BTR[186] BTR[187] BTR[188]
+ BTR[189] BTR[190] BTR[191] BTR[192] BTR[193] BTR[194] BTR[195] BTR[196]
+ BTR[197] BTR[198] BTR[199] BTR[200] BTR[201] BTR[202] BTR[203] BTR[204]
+ BTR[205] BTR[206] BTR[207] BTR[208] BTR[209] BTR[210] BTR[211] BTR[212]
+ BTR[213] BTR[214] BTR[215] BTR[216] BTR[217] BTR[218] BTR[219] BTR[220]
+ BTR[221] BTR[222] BTR[223] BTR[224] BTR[225] BTR[226] BTR[227] BTR[228]
+ BTR[229] BTR[230] BTR[231] BTR[232] BTR[233] BTR[234] BTR[235] BTR[236]
+ BTR[237] BTR[238] BTR[239] BTR[240] BTR[241] BTR[242] BTR[243] BTR[244]
+ BTR[245] BTR[246] BTR[247] BTR[248] BTR[249] BTR[250] BTR[251] BTR[252]
+ BTR[253] BTR[254] BTR[255] LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3] RBB_R[0]
+ RBB_R[1] RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8]
+ RBB_R[9] RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15]
+ RBT_R[0] RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7]
+ RBT_R[8] RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14]
+ RBT_R[15] XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2] XARLSBA_R[3] XARMSBA_R[0]
+ XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] XARMSBB_R[0] XARMSBB_R[1]
+ XARMSBB_R[2] XARMSBB_R[3] XZB[0] DBL0 LCLKB
+ spram_4096x16m16b1pm2re1BNK1_SLIO m=1
XXspram_4096x16m16b1pm2re1BNK1_BK_0 BBR[0] BBR[1] BBR[2] BBR[3] BBR[4] BBR[5]
+ BBR[6] BBR[7] BBR[8] BBR[9] BBR[10] BBR[11] BBR[12] BBR[13] BBR[14] BBR[15]
+ BBR[16] BBR[17] BBR[18] BBR[19] BBR[20] BBR[21] BBR[22] BBR[23] BBR[24]
+ BBR[25] BBR[26] BBR[27] BBR[28] BBR[29] BBR[30] BBR[31] BBR[32] BBR[33]
+ BBR[34] BBR[35] BBR[36] BBR[37] BBR[38] BBR[39] BBR[40] BBR[41] BBR[42]
+ BBR[43] BBR[44] BBR[45] BBR[46] BBR[47] BBR[48] BBR[49] BBR[50] BBR[51]
+ BBR[52] BBR[53] BBR[54] BBR[55] BBR[56] BBR[57] BBR[58] BBR[59] BBR[60]
+ BBR[61] BBR[62] BBR[63] BBR[64] BBR[65] BBR[66] BBR[67] BBR[68] BBR[69]
+ BBR[70] BBR[71] BBR[72] BBR[73] BBR[74] BBR[75] BBR[76] BBR[77] BBR[78]
+ BBR[79] BBR[80] BBR[81] BBR[82] BBR[83] BBR[84] BBR[85] BBR[86] BBR[87]
+ BBR[88] BBR[89] BBR[90] BBR[91] BBR[92] BBR[93] BBR[94] BBR[95] BBR[96]
+ BBR[97] BBR[98] BBR[99] BBR[100] BBR[101] BBR[102] BBR[103] BBR[104]
+ BBR[105] BBR[106] BBR[107] BBR[108] BBR[109] BBR[110] BBR[111] BBR[112]
+ BBR[113] BBR[114] BBR[115] BBR[116] BBR[117] BBR[118] BBR[119] BBR[120]
+ BBR[121] BBR[122] BBR[123] BBR[124] BBR[125] BBR[126] BBR[127] BBR[128]
+ BBR[129] BBR[130] BBR[131] BBR[132] BBR[133] BBR[134] BBR[135] BBR[136]
+ BBR[137] BBR[138] BBR[139] BBR[140] BBR[141] BBR[142] BBR[143] BBR[144]
+ BBR[145] BBR[146] BBR[147] BBR[148] BBR[149] BBR[150] BBR[151] BBR[152]
+ BBR[153] BBR[154] BBR[155] BBR[156] BBR[157] BBR[158] BBR[159] BBR[160]
+ BBR[161] BBR[162] BBR[163] BBR[164] BBR[165] BBR[166] BBR[167] BBR[168]
+ BBR[169] BBR[170] BBR[171] BBR[172] BBR[173] BBR[174] BBR[175] BBR[176]
+ BBR[177] BBR[178] BBR[179] BBR[180] BBR[181] BBR[182] BBR[183] BBR[184]
+ BBR[185] BBR[186] BBR[187] BBR[188] BBR[189] BBR[190] BBR[191] BBR[192]
+ BBR[193] BBR[194] BBR[195] BBR[196] BBR[197] BBR[198] BBR[199] BBR[200]
+ BBR[201] BBR[202] BBR[203] BBR[204] BBR[205] BBR[206] BBR[207] BBR[208]
+ BBR[209] BBR[210] BBR[211] BBR[212] BBR[213] BBR[214] BBR[215] BBR[216]
+ BBR[217] BBR[218] BBR[219] BBR[220] BBR[221] BBR[222] BBR[223] BBR[224]
+ BBR[225] BBR[226] BBR[227] BBR[228] BBR[229] BBR[230] BBR[231] BBR[232]
+ BBR[233] BBR[234] BBR[235] BBR[236] BBR[237] BBR[238] BBR[239] BBR[240]
+ BBR[241] BBR[242] BBR[243] BBR[244] BBR[245] BBR[246] BBR[247] BBR[248]
+ BBR[249] BBR[250] BBR[251] BBR[252] BBR[253] BBR[254] BBR[255] BTR[0]
+ BTR[1] BTR[2] BTR[3] BTR[4] BTR[5] BTR[6] BTR[7] BTR[8] BTR[9] BTR[10]
+ BTR[11] BTR[12] BTR[13] BTR[14] BTR[15] BTR[16] BTR[17] BTR[18] BTR[19]
+ BTR[20] BTR[21] BTR[22] BTR[23] BTR[24] BTR[25] BTR[26] BTR[27] BTR[28]
+ BTR[29] BTR[30] BTR[31] BTR[32] BTR[33] BTR[34] BTR[35] BTR[36] BTR[37]
+ BTR[38] BTR[39] BTR[40] BTR[41] BTR[42] BTR[43] BTR[44] BTR[45] BTR[46]
+ BTR[47] BTR[48] BTR[49] BTR[50] BTR[51] BTR[52] BTR[53] BTR[54] BTR[55]
+ BTR[56] BTR[57] BTR[58] BTR[59] BTR[60] BTR[61] BTR[62] BTR[63] BTR[64]
+ BTR[65] BTR[66] BTR[67] BTR[68] BTR[69] BTR[70] BTR[71] BTR[72] BTR[73]
+ BTR[74] BTR[75] BTR[76] BTR[77] BTR[78] BTR[79] BTR[80] BTR[81] BTR[82]
+ BTR[83] BTR[84] BTR[85] BTR[86] BTR[87] BTR[88] BTR[89] BTR[90] BTR[91]
+ BTR[92] BTR[93] BTR[94] BTR[95] BTR[96] BTR[97] BTR[98] BTR[99] BTR[100]
+ BTR[101] BTR[102] BTR[103] BTR[104] BTR[105] BTR[106] BTR[107] BTR[108]
+ BTR[109] BTR[110] BTR[111] BTR[112] BTR[113] BTR[114] BTR[115] BTR[116]
+ BTR[117] BTR[118] BTR[119] BTR[120] BTR[121] BTR[122] BTR[123] BTR[124]
+ BTR[125] BTR[126] BTR[127] BTR[128] BTR[129] BTR[130] BTR[131] BTR[132]
+ BTR[133] BTR[134] BTR[135] BTR[136] BTR[137] BTR[138] BTR[139] BTR[140]
+ BTR[141] BTR[142] BTR[143] BTR[144] BTR[145] BTR[146] BTR[147] BTR[148]
+ BTR[149] BTR[150] BTR[151] BTR[152] BTR[153] BTR[154] BTR[155] BTR[156]
+ BTR[157] BTR[158] BTR[159] BTR[160] BTR[161] BTR[162] BTR[163] BTR[164]
+ BTR[165] BTR[166] BTR[167] BTR[168] BTR[169] BTR[170] BTR[171] BTR[172]
+ BTR[173] BTR[174] BTR[175] BTR[176] BTR[177] BTR[178] BTR[179] BTR[180]
+ BTR[181] BTR[182] BTR[183] BTR[184] BTR[185] BTR[186] BTR[187] BTR[188]
+ BTR[189] BTR[190] BTR[191] BTR[192] BTR[193] BTR[194] BTR[195] BTR[196]
+ BTR[197] BTR[198] BTR[199] BTR[200] BTR[201] BTR[202] BTR[203] BTR[204]
+ BTR[205] BTR[206] BTR[207] BTR[208] BTR[209] BTR[210] BTR[211] BTR[212]
+ BTR[213] BTR[214] BTR[215] BTR[216] BTR[217] BTR[218] BTR[219] BTR[220]
+ BTR[221] BTR[222] BTR[223] BTR[224] BTR[225] BTR[226] BTR[227] BTR[228]
+ BTR[229] BTR[230] BTR[231] BTR[232] BTR[233] BTR[234] BTR[235] BTR[236]
+ BTR[237] BTR[238] BTR[239] BTR[240] BTR[241] BTR[242] BTR[243] BTR[244]
+ BTR[245] BTR[246] BTR[247] BTR[248] BTR[249] BTR[250] BTR[251] BTR[252]
+ BTR[253] BTR[254] BTR[255] CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0]
+ GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GBW[8] GBW[9] GBW[10]
+ GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5]
+ GD[6] GD[7] GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[0]
+ GRD0[1] GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9]
+ GRD0[10] GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17]
+ GRD0[18] GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25]
+ GRD0[26] GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD0[32] GRD0[33]
+ GRD0[34] GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41]
+ GRD0[42] GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49]
+ GRD0[50] GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57]
+ GRD0[58] GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[0] GRD1[1]
+ GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10]
+ GRD1[11] GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18]
+ GRD1[19] GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26]
+ GRD1[27] GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD1[32] GRD1[33] GRD1[34]
+ GRD1[35] GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42]
+ GRD1[43] GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50]
+ GRD1[51] GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58]
+ GRD1[59] GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[0] GRD2[1] GRD2[2]
+ GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11]
+ GRD2[12] GRD2[13] GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19]
+ GRD2[20] GRD2[21] GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27]
+ GRD2[28] GRD2[29] GRD2[30] GRD2[31] GRD2[32] GRD2[33] GRD2[34] GRD2[35]
+ GRD2[36] GRD2[37] GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43]
+ GRD2[44] GRD2[45] GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51]
+ GRD2[52] GRD2[53] GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59]
+ GRD2[60] GRD2[61] GRD2[62] GRD2[63] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4]
+ GRD3[5] GRD3[6] GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13]
+ GRD3[14] GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21]
+ GRD3[22] GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29]
+ GRD3[30] GRD3[31] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37]
+ GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45]
+ GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53]
+ GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61]
+ GRD3[62] GRD3[63] LXWB_R[0] LXWB_R[1] LXWB_R[2] LXWB_R[3] QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] RBB_R[0] RBB_R[1]
+ RBB_R[2] RBB_R[3] RBB_R[4] RBB_R[5] RBB_R[6] RBB_R[7] RBB_R[8] RBB_R[9]
+ RBB_R[10] RBB_R[11] RBB_R[12] RBB_R[13] RBB_R[14] RBB_R[15] RBT_R[0]
+ RBT_R[1] RBT_R[2] RBT_R[3] RBT_R[4] RBT_R[5] RBT_R[6] RBT_R[7] RBT_R[8]
+ RBT_R[9] RBT_R[10] RBT_R[11] RBT_R[12] RBT_R[13] RBT_R[14] RBT_R[15]
+ RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1] RGRD1[2] RGRD1[3]
+ RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1] RGRD3[2] RGRD3[3]
+ RMO[0] RMO[1] RMO[2] VSB[1] VSB[2] VSB[3] VSB[4] WMO[0] WMO[1] WMO[2]
+ XARLSBA_R[0] XARLSBA_R[1] XARLSBA_R[2] XARLSBA_R[3] XARMSBA_R[0]
+ XARMSBA_R[1] XARMSBA_R[2] XARMSBA_R[3] XARMSBB_R[0] XARMSBB_R[1]
+ XARMSBB_R[2] XARMSBB_R[3] VSS VSSX VDDA CSH_ENB BPUI SPUI ZRR DBL0 LCLKB
+ PWR ag_ctrl CSH_RR EN ENB T0EN CSH_LD RWOUT RGD RGBW
+ spram_4096x16m16b1pm2re1BNK1_BK m=1
.ends spram_4096x16m16b1pm2re1BNK1

.subckt spram_4096x16m16b1pm2re1_TOP A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7]
+ A[8] A[9] A[10] A[11] BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5]
+ BADIO[6] BADIO[7] BADIO[8] BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13]
+ BADIO[14] BADIO[15] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7]
+ BWM[8] BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[0] D[1]
+ D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15]
+ Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13]
+ Q[14] Q[15] RM[0] RM[1] RM[2] TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6]
+ TA[7] TA[8] TA[9] TA[10] TA[11] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4]
+ TBWM[5] TBWM[6] TBWM[7] TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13]
+ TBWM[14] TBWM[15] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] TD[8]
+ TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] WM[0] WM[1] WM[2] VDD VSS
+ AWT LVTEST VSB400 VSB300 VSB200 VSB100 RA BISTE TCLK CLK TWE WE TCE CE SD
+ HN SL SZ
*.pininfo A[0]:B A[1]:B A[2]:B A[3]:B A[4]:B A[5]:B A[6]:B A[7]:B A[8]:B
*.pininfo A[9]:B A[10]:B A[11]:B BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B
*.pininfo BADIO[4]:B BADIO[5]:B BADIO[6]:B BADIO[7]:B BADIO[8]:B BADIO[9]:B
*.pininfo BADIO[10]:B BADIO[11]:B BADIO[12]:B BADIO[13]:B BADIO[14]:B
*.pininfo BADIO[15]:B BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B BWM[5]:B
*.pininfo BWM[6]:B BWM[7]:B BWM[8]:B BWM[9]:B BWM[10]:B BWM[11]:B BWM[12]:B
*.pininfo BWM[13]:B BWM[14]:B BWM[15]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B
*.pininfo D[5]:B D[6]:B D[7]:B D[8]:B D[9]:B D[10]:B D[11]:B D[12]:B D[13]:B
*.pininfo D[14]:B D[15]:B Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B Q[6]:B
*.pininfo Q[7]:B Q[8]:B Q[9]:B Q[10]:B Q[11]:B Q[12]:B Q[13]:B Q[14]:B
*.pininfo Q[15]:B RM[0]:B RM[1]:B RM[2]:B TA[0]:B TA[1]:B TA[2]:B TA[3]:B
*.pininfo TA[4]:B TA[5]:B TA[6]:B TA[7]:B TA[8]:B TA[9]:B TA[10]:B TA[11]:B
*.pininfo TBWM[0]:B TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B TBWM[5]:B
*.pininfo TBWM[6]:B TBWM[7]:B TBWM[8]:B TBWM[9]:B TBWM[10]:B TBWM[11]:B
*.pininfo TBWM[12]:B TBWM[13]:B TBWM[14]:B TBWM[15]:B TD[0]:B TD[1]:B TD[2]:B
*.pininfo TD[3]:B TD[4]:B TD[5]:B TD[6]:B TD[7]:B TD[8]:B TD[9]:B TD[10]:B
*.pininfo TD[11]:B TD[12]:B TD[13]:B TD[14]:B TD[15]:B WM[0]:B WM[1]:B
*.pininfo WM[2]:B VDD:B VSS:B AWT:B LVTEST:B VSB400:B VSB300:B VSB200:B
*.pininfo VSB100:B RA:B BISTE:B TCLK:B CLK:B TWE:B WE:B TCE:B CE:B SD:B HN:B
*.pininfo SL:B SZ:B
XXspram_4096x16m16b1pm2re1GP_0 BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4]
+ BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4] BWM[5] BWM[6]
+ BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2] Q[3] Q[4]
+ Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5] TBWM[6]
+ TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] VDD VSS PWR AWT
+ LVTEST VSB400 VSB300 VSB200 VSB100 RA WM[0] WM[1] WM[2] RM[0] RM[1] RM[2]
+ BISTE TCLK CLK TWE WE TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6] TA[7] TA[8]
+ TA[9] TA[10] TA[11] A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10]
+ A[11] TCE CE SD HN SL SZ BPUI SPUI CACHE_MISS BADIO[8] BADIO[9] BADIO[10]
+ BADIO[11] BADIO[12] BADIO[13] BADIO[14] BADIO[15] BWM[8] BWM[9] BWM[10]
+ BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[8] D[9] D[10] D[11] D[12] D[13]
+ D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] TBWM[8] TBWM[9]
+ TBWM[10] TBWM[11] TBWM[12] TBWM[13] TBWM[14] TBWM[15] TD[8] TD[9] TD[10]
+ TD[11] TD[12] TD[13] TD[14] TD[15] Q_RED spram_4096x16m16b1pm2re1GP m=1
XXspram_4096x16m16b1pm2re1GLBIO_0 BADIO[0] BADIO[1] BADIO[2] BADIO[3]
+ BADIO[4] BADIO[5] BADIO[6] BADIO[7] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4]
+ BWM[5] BWM[6] BWM[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2]
+ Q[3] Q[4] Q[5] Q[6] Q[7] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4] TBWM[5]
+ TBWM[6] TBWM[7] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] VSS VDD
+ GBW[0] GBW[1] GBW[2] GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GD[0] GD[1] GD[2]
+ GD[3] GD[4] GD[5] GD[6] GD[7] GRD0[0] GRD0[1] GRD0[2] GRD0[3] GRD0[4]
+ GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10] GRD0[11] GRD0[12] GRD0[13]
+ GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18] GRD0[19] GRD0[20] GRD0[21]
+ GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26] GRD0[27] GRD0[28] GRD0[29]
+ GRD0[30] GRD0[31] GRD1[0] GRD1[1] GRD1[2] GRD1[3] GRD1[4] GRD1[5] GRD1[6]
+ GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11] GRD1[12] GRD1[13] GRD1[14]
+ GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19] GRD1[20] GRD1[21] GRD1[22]
+ GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27] GRD1[28] GRD1[29] GRD1[30]
+ GRD1[31] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4] GRD2[5] GRD2[6] GRD2[7]
+ GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13] GRD2[14] GRD2[15]
+ GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21] GRD2[22] GRD2[23]
+ GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29] GRD2[30] GRD2[31]
+ GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6] GRD3[7] GRD3[8]
+ GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14] GRD3[15] GRD3[16]
+ GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22] GRD3[23] GRD3[24]
+ GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30] GRD3[31] PWR BPUI
+ SPUI AWT LVTEST VSB400 VSB300 VSB200 VSB100 RA WM[0] WM[1] WM[2] RM[0]
+ RM[1] RM[2] BISTE TCLK CLK TWE WE TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6]
+ TA[7] TA[8] TA[9] TA[10] TA[11] A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7]
+ A[8] A[9] A[10] A[11] TCE CE SD HN SL SZ EN ENB RMO[0] RMO[1] RMO[2] WMO[0]
+ WMO[1] WMO[2] ag_ctrl T0EN ZRR CSH_RR CSH_LD CSH_ENB RWOUT CSH_YS[0]
+ CSH_YS[1] CSH_YS[2] CSH_YS[3] VSB[1] VSB[2] VSB[3] VSB[4] QT[2] QT[3] QT[4]
+ QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] GRST BADIO[8]
+ BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13] BADIO[14] BADIO[15] BWM[8]
+ BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[8] D[9] D[10]
+ D[11] D[12] D[13] D[14] D[15] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15]
+ TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13] TBWM[14] TBWM[15] TD[8]
+ TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] Q_RED GBW[8] GBW[9] GBW[10]
+ GBW[11] GBW[12] GBW[13] GBW[14] GBW[15] GD[8] GD[9] GD[10] GD[11] GD[12]
+ GD[13] GD[14] GD[15] GRD0[32] GRD0[33] GRD0[34] GRD0[35] GRD0[36] GRD0[37]
+ GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42] GRD0[43] GRD0[44] GRD0[45]
+ GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50] GRD0[51] GRD0[52] GRD0[53]
+ GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58] GRD0[59] GRD0[60] GRD0[61]
+ GRD0[62] GRD0[63] GRD1[32] GRD1[33] GRD1[34] GRD1[35] GRD1[36] GRD1[37]
+ GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43] GRD1[44] GRD1[45]
+ GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51] GRD1[52] GRD1[53]
+ GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59] GRD1[60] GRD1[61]
+ GRD1[62] GRD1[63] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37]
+ GRD3[38] GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45]
+ GRD3[46] GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53]
+ GRD3[54] GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61]
+ GRD3[62] GRD3[63] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RGBW RGD spram_4096x16m16b1pm2re1GLBIO m=1
XXspram_4096x16m16b1pm2re1BNK1_0 BBMX[0] BBMX[1] BBMX[2] BBMX[3] BBMX[4]
+ BBMX[5] BBMX[6] BBMX[7] BBMX[8] BBMX[9] BBMX[10] BBMX[11] BBMX[12] BBMX[13]
+ BBMX[14] BBMX[15] BBMX[16] BBMX[17] BBMX[18] BBMX[19] BBMX[20] BBMX[21]
+ BBMX[22] BBMX[23] BBMX[24] BBMX[25] BBMX[26] BBMX[27] BBMX[28] BBMX[29]
+ BBMX[30] BBMX[31] BBMX[32] BBMX[33] BBMX[34] BBMX[35] BBMX[36] BBMX[37]
+ BBMX[38] BBMX[39] BBMX[40] BBMX[41] BBMX[42] BBMX[43] BBMX[44] BBMX[45]
+ BBMX[46] BBMX[47] BBMX[48] BBMX[49] BBMX[50] BBMX[51] BBMX[52] BBMX[53]
+ BBMX[54] BBMX[55] BBMX[56] BBMX[57] BBMX[58] BBMX[59] BBMX[60] BBMX[61]
+ BBMX[62] BBMX[63] BTMX[0] BTMX[1] BTMX[2] BTMX[3] BTMX[4] BTMX[5] BTMX[6]
+ BTMX[7] BTMX[8] BTMX[9] BTMX[10] BTMX[11] BTMX[12] BTMX[13] BTMX[14]
+ BTMX[15] BTMX[16] BTMX[17] BTMX[18] BTMX[19] BTMX[20] BTMX[21] BTMX[22]
+ BTMX[23] BTMX[24] BTMX[25] BTMX[26] BTMX[27] BTMX[28] BTMX[29] BTMX[30]
+ BTMX[31] BTMX[32] BTMX[33] BTMX[34] BTMX[35] BTMX[36] BTMX[37] BTMX[38]
+ BTMX[39] BTMX[40] BTMX[41] BTMX[42] BTMX[43] BTMX[44] BTMX[45] BTMX[46]
+ BTMX[47] BTMX[48] BTMX[49] BTMX[50] BTMX[51] BTMX[52] BTMX[53] BTMX[54]
+ BTMX[55] BTMX[56] BTMX[57] BTMX[58] BTMX[59] BTMX[60] BTMX[61] BTMX[62]
+ BTMX[63] CSH_YS[0] CSH_YS[1] CSH_YS[2] CSH_YS[3] GBW[0] GBW[1] GBW[2]
+ GBW[3] GBW[4] GBW[5] GBW[6] GBW[7] GBW[8] GBW[9] GBW[10] GBW[11] GBW[12]
+ GBW[13] GBW[14] GBW[15] GD[0] GD[1] GD[2] GD[3] GD[4] GD[5] GD[6] GD[7]
+ GD[8] GD[9] GD[10] GD[11] GD[12] GD[13] GD[14] GD[15] GRD0[0] GRD0[1]
+ GRD0[2] GRD0[3] GRD0[4] GRD0[5] GRD0[6] GRD0[7] GRD0[8] GRD0[9] GRD0[10]
+ GRD0[11] GRD0[12] GRD0[13] GRD0[14] GRD0[15] GRD0[16] GRD0[17] GRD0[18]
+ GRD0[19] GRD0[20] GRD0[21] GRD0[22] GRD0[23] GRD0[24] GRD0[25] GRD0[26]
+ GRD0[27] GRD0[28] GRD0[29] GRD0[30] GRD0[31] GRD0[32] GRD0[33] GRD0[34]
+ GRD0[35] GRD0[36] GRD0[37] GRD0[38] GRD0[39] GRD0[40] GRD0[41] GRD0[42]
+ GRD0[43] GRD0[44] GRD0[45] GRD0[46] GRD0[47] GRD0[48] GRD0[49] GRD0[50]
+ GRD0[51] GRD0[52] GRD0[53] GRD0[54] GRD0[55] GRD0[56] GRD0[57] GRD0[58]
+ GRD0[59] GRD0[60] GRD0[61] GRD0[62] GRD0[63] GRD1[0] GRD1[1] GRD1[2]
+ GRD1[3] GRD1[4] GRD1[5] GRD1[6] GRD1[7] GRD1[8] GRD1[9] GRD1[10] GRD1[11]
+ GRD1[12] GRD1[13] GRD1[14] GRD1[15] GRD1[16] GRD1[17] GRD1[18] GRD1[19]
+ GRD1[20] GRD1[21] GRD1[22] GRD1[23] GRD1[24] GRD1[25] GRD1[26] GRD1[27]
+ GRD1[28] GRD1[29] GRD1[30] GRD1[31] GRD1[32] GRD1[33] GRD1[34] GRD1[35]
+ GRD1[36] GRD1[37] GRD1[38] GRD1[39] GRD1[40] GRD1[41] GRD1[42] GRD1[43]
+ GRD1[44] GRD1[45] GRD1[46] GRD1[47] GRD1[48] GRD1[49] GRD1[50] GRD1[51]
+ GRD1[52] GRD1[53] GRD1[54] GRD1[55] GRD1[56] GRD1[57] GRD1[58] GRD1[59]
+ GRD1[60] GRD1[61] GRD1[62] GRD1[63] GRD2[0] GRD2[1] GRD2[2] GRD2[3] GRD2[4]
+ GRD2[5] GRD2[6] GRD2[7] GRD2[8] GRD2[9] GRD2[10] GRD2[11] GRD2[12] GRD2[13]
+ GRD2[14] GRD2[15] GRD2[16] GRD2[17] GRD2[18] GRD2[19] GRD2[20] GRD2[21]
+ GRD2[22] GRD2[23] GRD2[24] GRD2[25] GRD2[26] GRD2[27] GRD2[28] GRD2[29]
+ GRD2[30] GRD2[31] GRD2[32] GRD2[33] GRD2[34] GRD2[35] GRD2[36] GRD2[37]
+ GRD2[38] GRD2[39] GRD2[40] GRD2[41] GRD2[42] GRD2[43] GRD2[44] GRD2[45]
+ GRD2[46] GRD2[47] GRD2[48] GRD2[49] GRD2[50] GRD2[51] GRD2[52] GRD2[53]
+ GRD2[54] GRD2[55] GRD2[56] GRD2[57] GRD2[58] GRD2[59] GRD2[60] GRD2[61]
+ GRD2[62] GRD2[63] GRD3[0] GRD3[1] GRD3[2] GRD3[3] GRD3[4] GRD3[5] GRD3[6]
+ GRD3[7] GRD3[8] GRD3[9] GRD3[10] GRD3[11] GRD3[12] GRD3[13] GRD3[14]
+ GRD3[15] GRD3[16] GRD3[17] GRD3[18] GRD3[19] GRD3[20] GRD3[21] GRD3[22]
+ GRD3[23] GRD3[24] GRD3[25] GRD3[26] GRD3[27] GRD3[28] GRD3[29] GRD3[30]
+ GRD3[31] GRD3[32] GRD3[33] GRD3[34] GRD3[35] GRD3[36] GRD3[37] GRD3[38]
+ GRD3[39] GRD3[40] GRD3[41] GRD3[42] GRD3[43] GRD3[44] GRD3[45] GRD3[46]
+ GRD3[47] GRD3[48] GRD3[49] GRD3[50] GRD3[51] GRD3[52] GRD3[53] GRD3[54]
+ GRD3[55] GRD3[56] GRD3[57] GRD3[58] GRD3[59] GRD3[60] GRD3[61] GRD3[62]
+ GRD3[63] LDB[0] LDB[1] LDB[2] LDB[3] LDB[4] LDB[5] LDB[6] LDB[7] LDB[8]
+ LDB[9] LDB[10] LDB[11] LDB[12] LDB[13] LDB[14] LDB[15] LDB[16] LDB[17]
+ LDB[18] LDB[19] LDB[20] LDB[21] LDB[22] LDB[23] LDB[24] LDB[25] LDB[26]
+ LDB[27] LDB[28] LDB[29] LDB[30] LDB[31] LDB[32] LDB[33] LDB[34] LDB[35]
+ LDB[36] LDB[37] LDB[38] LDB[39] LDB[40] LDB[41] LDB[42] LDB[43] LDB[44]
+ LDB[45] LDB[46] LDB[47] LDB[48] LDB[49] LDB[50] LDB[51] LDB[52] LDB[53]
+ LDB[54] LDB[55] LDB[56] LDB[57] LDB[58] LDB[59] LDB[60] LDB[61] LDB[62]
+ LDB[63] LDT[0] LDT[1] LDT[2] LDT[3] LDT[4] LDT[5] LDT[6] LDT[7] LDT[8]
+ LDT[9] LDT[10] LDT[11] LDT[12] LDT[13] LDT[14] LDT[15] LDT[16] LDT[17]
+ LDT[18] LDT[19] LDT[20] LDT[21] LDT[22] LDT[23] LDT[24] LDT[25] LDT[26]
+ LDT[27] LDT[28] LDT[29] LDT[30] LDT[31] LDT[32] LDT[33] LDT[34] LDT[35]
+ LDT[36] LDT[37] LDT[38] LDT[39] LDT[40] LDT[41] LDT[42] LDT[43] LDT[44]
+ LDT[45] LDT[46] LDT[47] LDT[48] LDT[49] LDT[50] LDT[51] LDT[52] LDT[53]
+ LDT[54] LDT[55] LDT[56] LDT[57] LDT[58] LDT[59] LDT[60] LDT[61] LDT[62]
+ LDT[63] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+ QT[12] QT[13] RBBMX[0] RBBMX[1] RBBMX[2] RBBMX[3] RBTMX[0] RBTMX[1]
+ RBTMX[2] RBTMX[3] RGRD0[0] RGRD0[1] RGRD0[2] RGRD0[3] RGRD1[0] RGRD1[1]
+ RGRD1[2] RGRD1[3] RGRD2[0] RGRD2[1] RGRD2[2] RGRD2[3] RGRD3[0] RGRD3[1]
+ RGRD3[2] RGRD3[3] RLDB[0] RLDB[1] RLDB[2] RLDB[3] RLDT[0] RLDT[1] RLDT[2]
+ RLDT[3] RMO[0] RMO[1] RMO[2] VSB[1] VSB[2] VSB[3] VSB[4] WMO[0] WMO[1]
+ WMO[2] XA[0] XA[1] XA[2] XA[3] XB[0] XB[1] XB[2] XB[3] XC[0] XC[1] XC[2]
+ XC[3] XWB[0] XWB[1] XWB[2] XWB[3] YSEL[0] YSEL[1] YSEL[2] YSEL[3] VSS VDD
+ PWR VSSX CSH_LD GRST CSH_RR ag_ctrl BPUI ZRR LRST WLRST SPUI RWOUT EN
+ CSH_ENB T0EN ENB RGD RGBW spram_4096x16m16b1pm2re1BNK1 m=1
.ends spram_4096x16m16b1pm2re1_TOP

.subckt spram_4096x16m16b1pm2re1 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8]
+ A[9] A[10] A[11] BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5]
+ BADIO[6] BADIO[7] BADIO[8] BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13]
+ BADIO[14] BADIO[15] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7]
+ BWM[8] BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[0] D[1]
+ D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15]
+ Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13]
+ Q[14] Q[15] RM[0] RM[1] RM[2] TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6]
+ TA[7] TA[8] TA[9] TA[10] TA[11] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4]
+ TBWM[5] TBWM[6] TBWM[7] TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13]
+ TBWM[14] TBWM[15] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] TD[8]
+ TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] WM[0] WM[1] WM[2] VDD VSS
+ AWT LVTEST VSB400 VSB300 VSB200 VSB100 RA BISTE TCLK CLK TWE WE TCE CE SD
+ HN SL SZ
*.pininfo A[0]:B A[1]:B A[2]:B A[3]:B A[4]:B A[5]:B A[6]:B A[7]:B A[8]:B
*.pininfo A[9]:B A[10]:B A[11]:B BADIO[0]:B BADIO[1]:B BADIO[2]:B BADIO[3]:B
*.pininfo BADIO[4]:B BADIO[5]:B BADIO[6]:B BADIO[7]:B BADIO[8]:B BADIO[9]:B
*.pininfo BADIO[10]:B BADIO[11]:B BADIO[12]:B BADIO[13]:B BADIO[14]:B
*.pininfo BADIO[15]:B BWM[0]:B BWM[1]:B BWM[2]:B BWM[3]:B BWM[4]:B BWM[5]:B
*.pininfo BWM[6]:B BWM[7]:B BWM[8]:B BWM[9]:B BWM[10]:B BWM[11]:B BWM[12]:B
*.pininfo BWM[13]:B BWM[14]:B BWM[15]:B D[0]:B D[1]:B D[2]:B D[3]:B D[4]:B
*.pininfo D[5]:B D[6]:B D[7]:B D[8]:B D[9]:B D[10]:B D[11]:B D[12]:B D[13]:B
*.pininfo D[14]:B D[15]:B Q[0]:B Q[1]:B Q[2]:B Q[3]:B Q[4]:B Q[5]:B Q[6]:B
*.pininfo Q[7]:B Q[8]:B Q[9]:B Q[10]:B Q[11]:B Q[12]:B Q[13]:B Q[14]:B
*.pininfo Q[15]:B RM[0]:B RM[1]:B RM[2]:B TA[0]:B TA[1]:B TA[2]:B TA[3]:B
*.pininfo TA[4]:B TA[5]:B TA[6]:B TA[7]:B TA[8]:B TA[9]:B TA[10]:B TA[11]:B
*.pininfo TBWM[0]:B TBWM[1]:B TBWM[2]:B TBWM[3]:B TBWM[4]:B TBWM[5]:B
*.pininfo TBWM[6]:B TBWM[7]:B TBWM[8]:B TBWM[9]:B TBWM[10]:B TBWM[11]:B
*.pininfo TBWM[12]:B TBWM[13]:B TBWM[14]:B TBWM[15]:B TD[0]:B TD[1]:B TD[2]:B
*.pininfo TD[3]:B TD[4]:B TD[5]:B TD[6]:B TD[7]:B TD[8]:B TD[9]:B TD[10]:B
*.pininfo TD[11]:B TD[12]:B TD[13]:B TD[14]:B TD[15]:B WM[0]:B WM[1]:B
*.pininfo WM[2]:B VDD:B VSS:B AWT:B LVTEST:B VSB400:B VSB300:B VSB200:B
*.pininfo VSB100:B RA:B BISTE:B TCLK:B CLK:B TWE:B WE:B TCE:B CE:B SD:B HN:B
*.pininfo SL:B SZ:B
XXspram_4096x16m16b1pm2re1_TOP A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8]
+ A[9] A[10] A[11] BADIO[0] BADIO[1] BADIO[2] BADIO[3] BADIO[4] BADIO[5]
+ BADIO[6] BADIO[7] BADIO[8] BADIO[9] BADIO[10] BADIO[11] BADIO[12] BADIO[13]
+ BADIO[14] BADIO[15] BWM[0] BWM[1] BWM[2] BWM[3] BWM[4] BWM[5] BWM[6] BWM[7]
+ BWM[8] BWM[9] BWM[10] BWM[11] BWM[12] BWM[13] BWM[14] BWM[15] D[0] D[1]
+ D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15]
+ Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13]
+ Q[14] Q[15] RM[0] RM[1] RM[2] TA[0] TA[1] TA[2] TA[3] TA[4] TA[5] TA[6]
+ TA[7] TA[8] TA[9] TA[10] TA[11] TBWM[0] TBWM[1] TBWM[2] TBWM[3] TBWM[4]
+ TBWM[5] TBWM[6] TBWM[7] TBWM[8] TBWM[9] TBWM[10] TBWM[11] TBWM[12] TBWM[13]
+ TBWM[14] TBWM[15] TD[0] TD[1] TD[2] TD[3] TD[4] TD[5] TD[6] TD[7] TD[8]
+ TD[9] TD[10] TD[11] TD[12] TD[13] TD[14] TD[15] WM[0] WM[1] WM[2] VDD VSS
+ AWT LVTEST VSB400 VSB300 VSB200 VSB100 RA BISTE TCLK CLK TWE WE TCE CE SD
+ HN SL SZ spram_4096x16m16b1pm2re1_TOP m=1
.ends spram_4096x16m16b1pm2re1
